# Repository EwoudVV/ducktop2 (continued)

## KiCad design ducktop2.kicad_pcb (continued)

Schematic: 16_gigabit_ethernet.kicad_sch

Parts:
C500, C501, C502, C503: 220n 16V X7R PCIe TX AC per current Mu guide; C_0402_1005Metric; MPN GRM155R71C224KA12D
C504, C505, C506, C507, C508, C509, C510, C511: 100n 16V X7R local decoupling; C_0402_1005Metric; MPN GRM155R71C104KA88D
C512: 10u 6.3V X7R RTL8111H REGOUT bulk; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C513: 100n 16V X7R magnetics center-tap bypass; C_0402_1005Metric; MPN GRM155R71C104KA88D
C514: 1n 2kV X7R 10% shield-to-digital return; C_1812_4532Metric; MPN C1812C102KGRACTU
C515, C516: 12p C0G 5% crystal load; C_0402_1005Metric; MPN GRM1555C1H120JA01
J500: JXD1-1022NL recessed 1GbE RJ45; JXD1-1022NL_MidMount; MPN JXD1-1022NL
R500: 1M 1% crystal feedback; R_0402_1005Metric; MPN RC0402FR-071ML
R501: 2.49k 1% RTL8111H RSET; R_0402_1005Metric; MPN RC0402FR-072K49L
R502: 10k 1% ISOLATEB pull-up; R_0402_1005Metric; MPN RC0402FR-0710KL
R503: 10k 1% PCIe WAKE# pull-up; R_0402_1005Metric; MPN RC0402FR-0710KL
R504: 470R 1% yellow activity LED; R_0402_1005Metric; MPN RC0402FR-07470RL
R505: 470R 1% green 1000M indicator LED; R_0402_1005Metric; MPN RC0402FR-07470RL
R506: DNP 0R direct shield-to-GND option; R_1206_3216Metric; not fitted
U500: RTL8111H-CG-RH PCIe Gigabit Ethernet; QFN-32-1EP_4x4mm_P0.4mm_EP2.65x2.65mm; MPN RTL8111H-CG-RH
U501, U502: D3V3XA4B10LP-7 four-channel 0.3pF Ethernet ESD; Diodes_UDFN-10_1x2.5mm_P0.5mm; MPN D3V3XA4B10LP-7
Y500: ECS-250-8-33-AGN-TR 25MHz 8pF crystal; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN ECS-250-8-33-AGN-TR

Connections:
/GBE_CLKREQ_N: U500.12 (CLKREQB_OD); also elsewhere on the board
/GBE_HOST_RX_N: C503.2; also elsewhere on the board
/GBE_HOST_RX_P: C502.2; also elsewhere on the board
/GBE_HOST_TX_N: C501.1; also elsewhere on the board
/GBE_HOST_TX_P: C500.1; also elsewhere on the board
/GBE_REFCLK_N: U500.16 (REFCLK_N); also elsewhere on the board
/GBE_REFCLK_P: U500.15 (REFCLK_P); also elsewhere on the board
/Gigabit Ethernet/ETH_1V0: C507.1, C508.1, C509.1, C510.1, C511.1, C512.1, U500.3 (AVDD10), U500.8 (AVDD10), U500.22 (DVDD10), U500.24 (REGOUT), U500.30 (AVDD10)
/Gigabit Ethernet/ETH_CHASSIS: C514.1, J500.SH (SHIELD), R506.1
/Gigabit Ethernet/ETH_CT: C513.1, J500.3 (CT1), J500.6 (CT2), J500.9 (CT3), J500.12 (CT4)
/Gigabit Ethernet/ETH_LED_1000_A: J500.16 (GREEN_A), R505.2
/Gigabit Ethernet/ETH_LED_1000_N: J500.15 (GREEN_K), U500.26 (LED1)
/Gigabit Ethernet/ETH_LED_ACT_A: J500.14 (YELLOW_A), R504.2
/Gigabit Ethernet/ETH_LED_ACT_N: J500.13 (YELLOW_K), U500.25 (LED2)
/Gigabit Ethernet/ETH_MDI0_N: J500.2 (MD1-), U500.2 (MDIN0), U501.2
/Gigabit Ethernet/ETH_MDI0_P: J500.1 (MD1+), U500.1 (MDIP0), U501.1
/Gigabit Ethernet/ETH_MDI1_N: J500.5 (MD2-), U500.5 (MDIN1), U501.5
/Gigabit Ethernet/ETH_MDI1_P: J500.4 (MD2+), U500.4 (MDIP1), U501.4
/Gigabit Ethernet/ETH_MDI2_N: J500.8 (MD3-), U500.7 (MDIN2), U502.2
/Gigabit Ethernet/ETH_MDI2_P: J500.7 (MD3+), U500.6 (MDIP2), U502.1
/Gigabit Ethernet/ETH_MDI3_N: J500.11 (MD4-), U500.10 (MDIN3), U502.5
/Gigabit Ethernet/ETH_MDI3_P: J500.10 (MD4+), U500.9 (MDIP3), U502.4
/Gigabit Ethernet/ETH_RSET: R501.1, U500.31 (RSET)
/Gigabit Ethernet/ETH_XI: C515.1, R500.1, U500.28 (CKXTAL1), Y500.1
/Gigabit Ethernet/ETH_XO: C516.1, R500.2, U500.29 (CKXTAL2), Y500.3
/Gigabit Ethernet/GBE_HSI_N: C501.2, U500.14 (HSIN)
/Gigabit Ethernet/GBE_HSI_P: C500.2, U500.13 (HSIP)
/Gigabit Ethernet/GBE_HSO_N: C503.1, U500.18 (HSON)
/Gigabit Ethernet/GBE_HSO_P: C502.1, U500.17 (HSOP)
/Gigabit Ethernet/GBE_ISOLATE_N: R502.2, U500.20 (ISOLATEB)
/PCIE_3V3: C504.1, C505.1, C506.1, R502.1, R503.1, R504.1, R505.1, U500.11 (AVDD33), U500.23 (VDDREG), U500.32 (AVDD33); also elsewhere on the board
/PCIE_WAKE_N: R503.2, U500.21 (LANWAKEB); also elsewhere on the board
/PLTRST_SRC_N: U500.19 (PERSTB); also elsewhere on the board
GND: C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, R501.2, R506.2, U500.33 (GND), U501.3 (VSS), U501.8 (VSS), U502.3 (VSS), U502.8 (VSS), Y500.2 (G), Y500.4 (G); also elsewhere on the board

Notes on the sheet:
== Native PCIe Gigabit Ethernet on LattePanda Mu default HSIO6 ==
RTL8111H support circuit follows LattePanda's DFR1142 Mu carrier reference: HSIO6, REFCLK4, CLKREQ4, and PLT_RST.
JXD1-1022NL is a true recessed through-hole mid-mount RJ45 with integrated magnetics; no external transformer is required.
== PCIe x1 host TX from Mu to RTL8111H; C500/C501 are at the Mu transmitter pads, not by U500 ==
== RTL8111H 3.3V / internal 1.0V rails and reset-side straps ==
== 25MHz reference crystal; 12pF legs implement the qualified 8pF load including about 2pF stray ==
== Four 100-ohm MDI pairs, low-capacitance ESD, and integrated-magnetics RJ45 ==
== Connector shield / aluminum chassis interface ==
LAYOUT: PCIe Gen3 pairs are 85-ohm differential; for this on-board PCIe device, place C500-C503 beside U500 per the Mu guide and route over an uninterrupted reference plane.
LAYOUT: MDI pairs are 100-ohm differential. Put U501/U502 immediately behind J500, avoid stubs, and do not route digital signals under the magnetics.
MECHANICAL: manufacturer body 17.58 x 26.06 x 11.30mm; PCB/panel plane is 2.03mm behind the front face; panel opening 17.98 x 9.69mm.
RELEASE HOLD: verify all four unnumbered shell stakes are common and confirm LED copper lands on one physical JXD1 sample before ordering the motherboard.
ASSEMBLY HOLD: ask the assembler to confirm through-hole mid-mount RJ45 support and whether J500 is manual/post-reflow insertion.
LED HOLD: RTL8111H pin 26 is the default 1000M indication, not a generic link LED. Verify both jack LEDs at 10/100/1000 on hardware.

Schematic: 12_keyboard_interface.kicad_sch

Parts:
C318: 100n DNP keyboard 3V3 reserve; C_0603_1608Metric; not fitted
C319: 10u keyboard RGB switched-output bulk; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C322: 100n keyboard RGB switch input; C_0603_1608Metric; MPN GRM188R71H104KA93D
C323: 100n keyboard RGB switch output; C_0603_1608Metric; MPN GRM188R71H104KA93D
C324: 100n keyboard RGB buffer local; C_0603_1608Metric; MPN GRM188R71H104KA93D
J310: Mainboard keyboard FFC to MX ULP daughterboard; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal; MPN FH12-30S-0.5SH(55)
R360, R361, R362, R363, R364, R365, R366, R367, R368, R369, R370, R371, R372, R373, R374, R376, R377, R378, R379, R380, R381, R382, R383: 1k keyboard matrix series; R_0603_1608Metric; MPN RC0603FR-071KL
R375: 100R keyboard RGB data series; R_0603_1608Metric; MPN RC0603FR-07100RL
R384: 100R keyboard I2C SCL series; R_0603_1608Metric; MPN RC0603FR-07100RL
R385: 100R keyboard I2C SDA series; R_0603_1608Metric; MPN RC0603FR-07100RL
R386: 0R DNP DO-NOT-FIT keyboard 5V protection bypass; R_0603_1608Metric; not fitted
R387: 0R DNP keyboard 3V3 option; R_0603_1608Metric; not fitted
R388: 66.5k 1% keyboard RGB 0.40A ILIM; R_0603_1608Metric; MPN RC0603FR-0766K5L
R389: 100k keyboard RGB enable default-off; R_0603_1608Metric; MPN RC0603FR-07100KL
R390: 10k keyboard RGB fault pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R391: 100k keyboard RGB data default-low; R_0603_1608Metric; MPN RC0603FR-07100KL
U310: TPS2553D keyboard RGB 5V switch 0.40A nominal; SOT-23-6; MPN TPS2553DDBVR
U311: SN74AHCT1G126 keyboard RGB 3V3-to-5V buffer; SOT-23-5; MPN SN74AHCT1G126DBVR

Connections:
/I2C_SCL: R384.1; also elsewhere on the board
/I2C_SDA: R385.1; also elsewhere on the board
/KB_COL0: R360.1; also elsewhere on the board
/KB_COL1: R361.1; also elsewhere on the board
/KB_COL2: R362.1; also elsewhere on the board
/KB_COL3: R363.1; also elsewhere on the board
/KB_COL4: R364.1; also elsewhere on the board
/KB_COL5: R365.1; also elsewhere on the board
/KB_COL6: R366.1; also elsewhere on the board
/KB_COL7: R367.1; also elsewhere on the board
/KB_COL8: R368.1; also elsewhere on the board
/KB_COL9: R369.1; also elsewhere on the board
/KB_COL10: R370.1; also elsewhere on the board
/KB_COL11: R371.1; also elsewhere on the board
/KB_COL12: R372.1; also elsewhere on the board
/KB_COL13: R373.1; also elsewhere on the board
/KB_COL14: R374.1; also elsewhere on the board
/KB_RGB_DATA_3V3: R391.1, U311.2; also elsewhere on the board
/KB_RGB_FAULT_N: R390.2, U310.4 (~FAULT); also elsewhere on the board
/KB_RGB_PWR_EN: R389.1, U310.3 (EN), U311.1; also elsewhere on the board
/KB_ROW0: R376.1; also elsewhere on the board
/KB_ROW1: R377.1; also elsewhere on the board
/KB_ROW2: R378.1; also elsewhere on the board
/KB_ROW3: R379.1; also elsewhere on the board
/KB_ROW4: R380.1; also elsewhere on the board
/KB_ROW5: R381.1; also elsewhere on the board
/KB_ROW6: R382.1; also elsewhere on the board
/KB_ROW7: R383.1; also elsewhere on the board
/Keyboard Mainboard FFC/KB_FFC_3V3: C318.1, J310.29, R387.2
/Keyboard Mainboard FFC/KB_FFC_5V: C319.1, C323.1, J310.2, R386.2, U310.6 (OUT)
/Keyboard Mainboard FFC/KB_FFC_COL0: J310.18, R360.2
/Keyboard Mainboard FFC/KB_FFC_COL1: J310.17, R361.2
/Keyboard Mainboard FFC/KB_FFC_COL2: J310.16, R362.2
/Keyboard Mainboard FFC/KB_FFC_COL3: J310.15, R363.2
/Keyboard Mainboard FFC/KB_FFC_COL4: J310.14, R364.2
/Keyboard Mainboard FFC/KB_FFC_COL5: J310.13, R365.2
/Keyboard Mainboard FFC/KB_FFC_COL6: J310.12, R366.2
/Keyboard Mainboard FFC/KB_FFC_COL7: J310.11, R367.2
/Keyboard Mainboard FFC/KB_FFC_COL8: J310.10, R368.2
/Keyboard Mainboard FFC/KB_FFC_COL9: J310.9, R369.2
/Keyboard Mainboard FFC/KB_FFC_COL10: J310.8, R370.2
/Keyboard Mainboard FFC/KB_FFC_COL11: J310.7, R371.2
/Keyboard Mainboard FFC/KB_FFC_COL12: J310.6, R372.2
/Keyboard Mainboard FFC/KB_FFC_COL13: J310.5, R373.2
/Keyboard Mainboard FFC/KB_FFC_COL14: J310.4, R374.2
/Keyboard Mainboard FFC/KB_FFC_I2C_SCL: J310.28, R384.2
/Keyboard Mainboard FFC/KB_FFC_I2C_SDA: J310.27, R385.2
/Keyboard Mainboard FFC/KB_FFC_RGB_DATA: J310.3, R375.2
/Keyboard Mainboard FFC/KB_FFC_ROW0: J310.26, R376.2
/Keyboard Mainboard FFC/KB_FFC_ROW1: J310.25, R377.2
/Keyboard Mainboard FFC/KB_FFC_ROW2: J310.24, R378.2
/Keyboard Mainboard FFC/KB_FFC_ROW3: J310.23, R379.2
/Keyboard Mainboard FFC/KB_FFC_ROW4: J310.22, R380.2
/Keyboard Mainboard FFC/KB_FFC_ROW5: J310.21, R381.2
/Keyboard Mainboard FFC/KB_FFC_ROW6: J310.20, R382.2
/Keyboard Mainboard FFC/KB_FFC_ROW7: J310.19, R383.2
/Keyboard Mainboard FFC/KB_RGB_DATA_5V: R375.1, U311.4
/Keyboard Mainboard FFC/KB_RGB_ILIM: R388.1, U310.5 (ILIM)
/MCU_3V3: R387.1, R390.1; also elsewhere on the board
/SYS_5V: C322.1, C324.1, R386.1, U310.1 (IN), U311.5 (VCC); also elsewhere on the board
GND: C318.2, C319.2, C322.2, C323.2, C324.2, J310.1, J310.30, J310.MP, R388.2, R389.2, R391.2, U310.2 (GND), U311.3 (GND); also elsewhere on the board

Notes on the sheet:
== Mainboard keyboard FFC interface ==
This sheet is the motherboard-side connector only; the MX ULP switches and diodes live on the separate keyboard PCB.
Keep this sheet in the main root so ducktop2.kicad_pcb imports only the laptop-side FFC connector, not keyboard-switch footprints.
NOTES:
J310 is deliberately pin-reversed relative to J320 for two top-side FH12 bottom-contact connectors and a Type-A same-side FFC.
Specified cable: Molex 0150200315, 30 circuits, 0.5 mm pitch, 30 mm, Type A / same-side contacts.
R386/R387 stay DNP. U310 limits the future RGB rail below 0.5A/contact and defaults off; rev A has no RGB load.
J310 pin 3 / rev-A J320 pin 28 repurposes unused COL15 for RGB data. Rows 5..7 and COL14 remain spare.
Rev B must add local LED bulk capacitance and firmware must enforce a 325mA LED budget; unrestricted full-white is unsupported.

Schematic: 05_power_inputs.kicad_sch

Parts:
C2000, C2040: 100n 100V TPD4S201 VBIAS; C_0805_2012Metric; MPN GRM21BR72A104KA01L
C2001, C2041: 820n 10V TPD4S201 VPWR; C_0805_2012Metric; MPN GRM21BR71A824KA01L
C2002, C2042: 100n EEPROM local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2003, C2043: 100n mux-control buffer local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2004, C2044: 10u TUSB1142 local; C_1206_3216Metric; MPN GRM31CR71A106KA01L
C2005, C2006, C2007, C2008, C2045, C2046, C2047, C2048: 100n TUSB1142 VCC local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2009, C2010, C2011, C2012, C2013, C2014, C2049, C2050, C2051, C2052, C2053, C2054: 220n USB3 TX AC coupling; C_0402_1005Metric; MPN GRM155R71C224KA12D
C2015, C2055: 4.7u 25V raw VBUS; pre-attach total below 10uF; C_1206_3216Metric; MPN GRM31CR71E475KA88L
C2016, C2017, C2018, C2019, C2056, C2057, C2058, C2059: 10n 50V connector VBUS HF; C_0402_1005Metric; MPN GRM155R71H103KA88D
C2020, C2060: 6.8u 25V X7R TPS25751A LDO3V3; verify >=5u effect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; C_1206_3216Metric; MPN GRM31CR71E685KA88L
C2021, C2061: 10u 16V X7R TPS25751A LDO1V5; verify 4.5-12u effe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; C_1206_3216Metric; MPN GRM31CR71C106KA01L
C2022, C2062: 10u TPS25751A VIN3V3; C_1206_3216Metric; MPN GRM31CR71A106KA01L
C2023, C2063: 270p C0G CC1 total-capacitance component; C_0402_1005Metric; MPN GRM1555C1H271JA01D
C2024, C2064: 270p C0G CC2 total-capacitance component; C_0402_1005Metric; MPN GRM1555C1H271JA01D
C2025, C2026, C2065, C2066: 100u 10V PP5V source bulk; CP_EIA-7343-31_Kemet-D; MPN T520D107M010ATE070
C2027, C2067: 10u PP5V local ceramic; C_1206_3216Metric; MPN GRM31CR71A106KA01L
C2028, C2068: 68u 25V PPHV sink bulk; CP_EIA-7343-31_Kemet-D; MPN T521V686M025ATE050
C2029, C2069: 100n 50V PPHV local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2030, C2070: 100n USB2 switch local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2080, C2090: 100n 50V eFuse input local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2081, C2091: 10u 25V eFuse output; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C2082, C2092: 22n eFuse dVdT; C_0402_1005Metric; MPN GRM155R71H223KA12D
C2140: 100n selector INTVCC; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2141: 15n selector TMR approx 240ms; C_0402_1005Metric; MPN GRM155R71H153KA12D
C2142, C2143, C2144, C2145: 100n 50V selector local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2146: 100u 35V selected-PD hold-up; CP_Elec_6.3x5.8; MPN EEHZK1V101XP
D2080, D2090: B340A eFuse output negative-transient clamp; D_SMA; MPN B340A-13-F
D2100, D2101, D2102, D2103, D2104, D2105, D2106, D2107, D2120, D2121, D2122, D2123, D2124, D2125, D2126, D2127: TPD1E0B04DPLR 0.13pF USB3 ESD; D_0201_0603Metric; MPN TPD1E0B04DPLR
J11: USB-C dual-role data/PD port J11; USB_C_Receptacle_Molex_105450-0101; MPN 105450-0101
J21: USB-C dual-role data/PD port J21; USB_C_Receptacle_Molex_105450-0101; MPN 105450-0101
Q15, Q16, Q17, Q18: SiSS4409DN 40V reverse-blocking PMOS; Vishay_PowerPAK_1212-8_Single; MPN SiSS4409DN-T1-GE3
Q2001, Q2002: 2N7002K DFP USB2 enable inverter; SOT-23; MPN 2N7002KT1G
R2000, R2040: 10k shared CC/USB2 protector FLT pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2001, R2041: 2.2k EEPROM SDA pull-up; R_0603_1608Metric; MPN RC0603FR-072K2L
R2002, R2042: 2.2k EEPROM SCL pull-up; R_0603_1608Metric; MPN RC0603FR-072K2L
R2003, R2043: 4.7k TCPC SDA pull-up; R_0603_1608Metric; MPN RC0603FR-074K7L
R2004, R2044: 4.7k TCPC SCL pull-up; R_0603_1608Metric; MPN RC0603FR-074K7L
R2005, R2045: 10k TCPC IRQ pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2006, R2046: 10k mux FLIP pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2007, R2047: 10k mux EN pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2008, R2048: 1k TUSB1142 MODE=0 strap; R_0603_1608Metric; MPN RC0603FR-071KL
R2009, R2049: 1k TUSB1142 VIO=3V3 strap; R_0603_1608Metric; MPN RC0603FR-071KL
R2010, R2050: 1k TUSB1142 EQCFG=0 strap; R_0603_1608Metric; MPN RC0603FR-071KL
R2011, R2051: 1k TUSB1142 SSEQ1=0 strap; R_0603_1608Metric; MPN RC0603FR-071KL
R2012, R2052: 10k TUSB1142 SLP_S0# pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2013, R2053: 100k mux FLIP input default-low; R_0603_1608Metric; MPN RC0603FR-07100KL
R2014, R2054: 100k data-attach input default-low; R_0603_1608Metric; MPN RC0603FR-07100KL
R2015, R2055: 10k I2Cc IRQ inactive pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2016, R2056: 100k USB2 switch default-disable pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R2017, R2057: 0R protector FLT wired-OR link; R_0603_1608Metric; MPN RC0603FR-070RL
R2018, R2058: 100k DFP-role input default-low; R_0603_1608Metric; MPN RC0603FR-07100KL
R2080, R2090: 887k 0.1% 15V eFuse UV/OV top; R_0603_1608Metric; MPN RT0603BRD07887KL
R2081, R2091: 27.4k 0.1% 15V eFuse UV/OV middle; R_0603_1608Metric; MPN RT0603BRD0727K4L
R2082, R2092: 68.1k 0.1% 15V eFuse UV/OV bottom; R_0603_1608Metric; MPN RT0603BRD0768K1L
R2083, R2093: 6.04k 1% eFuse 2.98A ILIM; R_0603_1608Metric; MPN RC0603FR-076K04L
R2084, R2094: 47k eFuse default-off pulldown; R_0603_1608Metric; MPN RC0603FR-0747KL
R2085, R2095: 10k path-enable series; R_0603_1608Metric; MPN RC0603FR-0710KL
R2086, R2096: 10k eFuse FLT pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2140, R2143: 1.00M 0.1% 15V UV top; R_0603_1608Metric; MPN RT0603BRD071ML
R2141, R2144: 19.6k 0.1% 15V window middle; R_0603_1608Metric; MPN RT0603BRD0719K6L
R2142, R2145: 63.4k 0.1% 15V OV bottom; R_0603_1608Metric; MPN RT0603BRD0763K4L
R2146: 10k PD1 VALID pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2147: 10k PD2 VALID pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
U14: LTC4418IUF#PBF dual-input PD selector; ADI_UF20_QFN20_4x4_P0.5_EP2.45; MPN LTC4418IUF#PBF
U41, U42: TPS25751AD USB-PD DRP controller; Texas_REF0038A_WQFN-38-2EP_6x4mm_P0.4; MPN TPS25751ADREFR
U720: TPS26630RGER PD1 default-off 3A sink eFuse; Texas_RGE0024H_VQFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_Thermal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; MPN TPS26630RGER
U721: TPS26630RGER PD2 default-off 3A sink eFuse; Texas_RGE0024H_VQFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_Thermal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; MPN TPS26630RGER
U2000, U2010: TUSB1142 USB 3.2 Gen 2 orientation redriver; Texas_RNQ0040A_WQFN-40-1EP_6x4mm_P0.4mm_EP4.7x2.7mm_Thermal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; MPN TUSB1142IRNQR
U2001, U2011: TPD4S201 CC and USB2 short-to-VBUS protector; Texas_RUK0020B_WQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm_Thermal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; MPN TPD4S201RUKR
U2002, U2012: CAT24C256 32KB private TPS25751A EEPROM; SOIC-8_3.9x4.9mm_P1.27mm; MPN CAT24C256WI-GT3
U2003, U2013: TS3USB30E DFP-qualified USB2 disconnect; TSSOP-10_3x3mm_P0.5mm; MPN TS3USB30EDGSR
U2004, U2014: SN74LVC2G07 partial-power-down mux controls; SOT-363_SC-70-6; MPN SN74LVC2G07DCKR
U2005, U2015: TVS2200 22V USB VBUS surge clamp; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TVS2200DRVR
U2006, U2016: SN74LVC1G08 DFP and attached qualifier; SOT-23-5; MPN SN74LVC1G08DBVR

Connections:
/HUB_DS1_DM: U2013.8 (D1-); also elsewhere on the board
/HUB_DS1_DP: U2013.2 (D1+); also elsewhere on the board
/HUB_DS1_SSRX_N: C2050.2; also elsewhere on the board
/HUB_DS1_SSRX_P: C2049.2; also elsewhere on the board
/HUB_DS1_SSTX_N: U2010.15 (SSTXn); also elsewhere on the board
/HUB_DS1_SSTX_P: U2010.16 (SSTXp); also elsewhere on the board
/MCU_3V3: C2022.1, C2062.1, R2000.1, R2003.1, R2004.1, R2005.1, R2040.1, R2043.1, R2044.1, R2045.1, R2086.1, R2096.1, R2146.1, R2147.1, U41.38 (VIN_3V3), U42.38 (VIN_3V3); also elsewhere on the board
/PD1_EFUSE_FAULT_N: R2086.2, U720.14 (~FLT); also elsewhere on the board
/PD1_I2C_SCL: R2004.2, U41.9 (I2Ct_SCL); also elsewhere on the board
/PD1_I2C_SDA: R2003.2, U41.8 (I2Ct_SDA); also elsewhere on the board
/PD1_PATH_EN: R2085.1; also elsewhere on the board
/PD1_TCPC_IRQ_N: R2005.2, U41.10 (I2Ct_IRQ); also elsewhere on the board
/PD1_VALID_N: R2146.2, U14.9 (~VALID1); also elsewhere on the board
/PD1_VBUS_RAW: C2015.1, C2016.1, C2017.1, C2018.1, C2019.1, J21.A4 (VBUS), J21.A9 (VBUS), J21.B4 (VBUS), J21.B9 (VBUS), U41.23 (VBUS_IN_(23-25)), U41.32 (VBUS_(32-33)), U2005.4 (IN), U2005.5 (IN), U2005.6 (IN); also elsewhere on the board
/PD2_EFUSE_FAULT_N: R2096.2, U721.14 (~FLT); also elsewhere on the board
/PD2_I2C_SCL: R2044.2, U42.9 (I2Ct_SCL); also elsewhere on the board
/PD2_I2C_SDA: R2043.2, U42.8 (I2Ct_SDA); also elsewhere on the board
/PD2_PATH_EN: R2095.1; also elsewhere on the board
/PD2_TCPC_IRQ_N: R2045.2, U42.10 (I2Ct_IRQ); also elsewhere on the board
/PD2_VALID_N: R2147.2, U14.10 (~VALID2); also elsewhere on the board
/PD2_VBUS_RAW: C2055.1, C2056.1, C2057.1, C2058.1, C2059.1, J11.A4 (VBUS), J11.A9 (VBUS), J11.B4 (VBUS), J11.B9 (VBUS), U42.23 (VBUS_IN_(23-25)), U42.32 (VBUS_(32-33)), U2015.4 (IN), U2015.5 (IN), U2015.6 (IN); also elsewhere on the board
/PD_PROTECT_FAULT_N: R2000.2, R2017.2, R2040.2, R2057.2; also elsewhere on the board
/Power Inputs/PD1_CC1_CONN: J21.A5 (CC1), U2001.4 (C_CC1), U2001.7 (RPD_G1)
/Power Inputs/PD1_CC1_SYS: C2023.1, U41.28 (CC1), U2001.12 (CC1)
/Power Inputs/PD1_CC2_CONN: J21.B5 (CC2), U2001.5 (C_CC2), U2001.6 (RPD_G2)
/Power Inputs/PD1_CC2_SYS: C2024.1, U41.29 (CC2), U2001.11 (CC2)
/Power Inputs/PD1_CC_ESD_VBIAS: C2000.1, U2001.3 (VBIAS)
/Power Inputs/PD1_CC_FAULT_LOCAL_N: R2017.1, U2001.9 (FLT)
/Power Inputs/PD1_CTX1_RAW_N: C2012.1, U2000.34 (CTX1n)
/Power Inputs/PD1_CTX1_RAW_P: C2011.1, U2000.33 (CTX1p)
/Power Inputs/PD1_CTX2_RAW_N: C2014.1, U2000.39 (CTX2n)
/Power Inputs/PD1_CTX2_RAW_P: C2013.1, U2000.40 (CTX2p)
/Power Inputs/PD1_DM_CONN: J21.A7 (D-), J21.B7 (D-), U2001.2 (C_SBU2)
/Power Inputs/PD1_DM_HOST_SWITCHED: U2001.14 (SBU2), U2003.6 (D-)
/Power Inputs/PD1_DP_CONN: J21.A6 (D+), J21.B6 (D+), U2001.1 (C_SBU1)
/Power Inputs/PD1_DP_HOST_SWITCHED: U2001.15 (SBU1), U2003.4 (D+)
/Power Inputs/PD1_DRAIN_THERMAL: U41.15 (DRAIN), U41.30 (DRAIN), U41.40 (DRAIN)
/Power Inputs/PD1_EEPROM_IRQ_N: R2015.2, U41.18 (I2Cc_IRQ)
/Power Inputs/PD1_EEPROM_SCL: R2002.2, U41.17 (I2Cc_SCL), U2002.6 (SCL)
/Power Inputs/PD1_EEPROM_SDA: R2001.2, U41.16 (I2Cc_SDA), U2002.5 (SDA)
/Power Inputs/PD1_EFUSE_DVDT: C2082.1, U720.9 (dVdT)
/Power Inputs/PD1_EFUSE_ILIM: R2083.1, U720.10 (ILIM)
/Power Inputs/PD1_EFUSE_OV: R2081.2, R2082.1, U720.7 (OVP)
/Power Inputs/PD1_EFUSE_SHDN: R2084.1, R2085.2, U720.12 (~SHDN)
/Power Inputs/PD1_EFUSE_UV: R2080.2, R2081.1, U720.6 (UVLO)
/Power Inputs/PD1_GPIO_ATTACH: R2014.1, U41.36 (GPIO7), U2006.2
/Power Inputs/PD1_GPIO_DFP: R2018.1, U41.26 (GPIO4/USB_P), U2006.1
/Power Inputs/PD1_GPIO_FLIP: R2013.1, U41.37 (GPIO6), U2004.1
/Power Inputs/PD1_HOST_ATTACHED: U2004.3, U2006.4
/Power Inputs/PD1_LDO1V5: C2021.1, U41.4 (LDO_1V5)
/Power Inputs/PD1_LDO3V3: C2001.1, C2002.1, C2020.1, R2001.1, R2002.1, R2015.1, U41.1 (LDO_3V3), U41.2 (ADCIN1), U2001.10 (VPWR), U2002.8 (VCC)
/Power Inputs/PD1_MUX_EN: Q2001.1 (G), R2007.2, U2000.26 (EN), U2004.4
/Power Inputs/PD1_MUX_EQCFG: R2010.1, U2000.3 (EQCFG)
/Power Inputs/PD1_MUX_FLIP: R2006.2, U2000.21 (FLIP/SCL), U2004.6
/Power Inputs/PD1_MUX_MODE: R2008.1, U2000.17 (MODE)
/Power Inputs/PD1_MUX_SLEEP_N: R2012.2, U2000.4 (SLP_S0#)
/Power Inputs/PD1_MUX_SSEQ1: R2011.1, U2000.2 (SSEQ1/A1)
/Power Inputs/PD1_MUX_VIO: R2009.1, U2000.14 (VIO_SEL)
/Power Inputs/PD1_PPHV: C2028.1, C2029.1, C2080.1, R2080.1, U41.20 (PPHV_(20-22)), U720.1 (IN), U720.2 (IN), U720.5 (IN_SYS)
/Power Inputs/PD1_RX1_N: D2105.1 (IO), J21.B10 (RX1-), U2000.31 (CRX1n)
/Power Inputs/PD1_RX1_P: D2104.1 (IO), J21.B11 (RX1+), U2000.30 (CRX1p)
/Power Inputs/PD1_RX2_N: D2107.1 (IO), J21.A10 (RX2-), U2000.36 (CRX2n)
/Power Inputs/PD1_RX2_P: D2106.1 (IO), J21.A11 (RX2+), U2000.37 (CRX2p)
/Power Inputs/PD1_SEL_FET_COMMON: C2143.1, Q15.2 (S), Q15.3 (S), Q15.4 (S), Q16.2 (S), Q16.3 (S), Q16.4 (S), U14.14 (VS1)
/Power Inputs/PD1_SEL_GATE: Q15.1 (G), Q16.1 (G), U14.13 (G1)
/Power Inputs/PD1_SEL_OV: R2141.2, R2142.1, U14.3 (OV1)
/Power Inputs/PD1_SEL_UV: R2140.2, R2141.1, U14.2 (UV1)
/Power Inputs/PD1_SSRX_RAW_N: C2010.1, U2000.18 (SSRXn)
/Power Inputs/PD1_SSRX_RAW_P: C2009.1, U2000.19 (SSRXp)
/Power Inputs/PD1_TX1_N: C2012.2, D2101.1 (IO), J21.A3 (TX1-)
/Power Inputs/PD1_TX1_P: C2011.2, D2100.1 (IO), J21.A2 (TX1+)
/Power Inputs/PD1_TX2_N: C2014.2, D2103.1 (IO), J21.B3 (TX2-)
/Power Inputs/PD1_TX2_P: C2013.2, D2102.1 (IO), J21.B2 (TX2+)
/Power Inputs/PD1_USB2_OE_N: Q2001.3 (D), R2016.2, U2003.9 (~OE)
/Power Inputs/PD1_VBUS_GATED: C2081.1, C2142.1, D2080.1 (K), Q15.5 (D(5-8)), R2140.1, U14.17 (V1), U720.17 (OUT), U720.18 (OUT)
/Power Inputs/PD2_CC1_CONN: J11.A5 (CC1), U2011.4 (C_CC1), U2011.7 (RPD_G1)
/Power Inputs/PD2_CC1_SYS: C2063.1, U42.28 (CC1), U2011.12 (CC1)
/Power Inputs/PD2_CC2_CONN: J11.B5 (CC2), U2011.5 (C_CC2), U2011.6 (RPD_G2)
/Power Inputs/PD2_CC2_SYS: C2064.1, U42.29 (CC2), U2011.11 (CC2)
/Power Inputs/PD2_CC_ESD_VBIAS: C2040.1, U2011.3 (VBIAS)
/Power Inputs/PD2_CC_FAULT_LOCAL_N: R2057.1, U2011.9 (FLT)
/Power Inputs/PD2_CTX1_RAW_N: C2052.1, U2010.34 (CTX1n)
/Power Inputs/PD2_CTX1_RAW_P: C2051.1, U2010.33 (CTX1p)
/Power Inputs/PD2_CTX2_RAW_N: C2054.1, U2010.39 (CTX2n)
/Power Inputs/PD2_CTX2_RAW_P: C2053.1, U2010.40 (CTX2p)
/Power Inputs/PD2_DM_CONN: J11.A7 (D-), J11.B7 (D-), U2011.2 (C_SBU2)
/Power Inputs/PD2_DM_HOST_SWITCHED: U2011.14 (SBU2), U2013.6 (D-)
/Power Inputs/PD2_DP_CONN: J11.A6 (D+), J11.B6 (D+), U2011.1 (C_SBU1)
/Power Inputs/PD2_DP_HOST_SWITCHED: U2011.15 (SBU1), U2013.4 (D+)
/Power Inputs/PD2_DRAIN_THERMAL: U42.15 (DRAIN), U42.30 (DRAIN), U42.40 (DRAIN)
/Power Inputs/PD2_EEPROM_IRQ_N: R2055.2, U42.18 (I2Cc_IRQ)
/Power Inputs/PD2_EEPROM_SCL: R2042.2, U42.17 (I2Cc_SCL), U2012.6 (SCL)
/Power Inputs/PD2_EEPROM_SDA: R2041.2, U42.16 (I2Cc_SDA), U2012.5 (SDA)
/Power Inputs/PD2_EFUSE_DVDT: C2092.1, U721.9 (dVdT)
/Power Inputs/PD2_EFUSE_ILIM: R2093.1, U721.10 (ILIM)
/Power Inputs/PD2_EFUSE_OV: R2091.2, R2092.1, U721.7 (OVP)
/Power Inputs/PD2_EFUSE_SHDN: R2094.1, R2095.2, U721.12 (~SHDN)
/Power Inputs/PD2_EFUSE_UV: R2090.2, R2091.1, U721.6 (UVLO)
/Power Inputs/PD2_GPIO_ATTACH: R2054.1, U42.36 (GPIO7), U2016.2
/Power Inputs/PD2_GPIO_DFP: R2058.1, U42.26 (GPIO4/USB_P), U2016.1
/Power Inputs/PD2_GPIO_FLIP: R2053.1, U42.37 (GPIO6), U2014.1
/Power Inputs/PD2_HOST_ATTACHED: U2014.3, U2016.4
/Power Inputs/PD2_LDO1V5: C2061.1, U42.4 (LDO_1V5)
/Power Inputs/PD2_LDO3V3: C2041.1, C2042.1, C2060.1, R2041.1, R2042.1, R2055.1, U42.1 (LDO_3V3), U2011.10 (VPWR), U2012.8 (VCC)
/Power Inputs/PD2_MUX_EN: Q2002.1 (G), R2047.2, U2010.26 (EN), U2014.4
/Power Inputs/PD2_MUX_EQCFG: R2050.1, U2010.3 (EQCFG)
/Power Inputs/PD2_MUX_FLIP: R2046.2, U2010.21 (FLIP/SCL), U2014.6
/Power Inputs/PD2_MUX_MODE: R2048.1, U2010.17 (MODE)
/Power Inputs/PD2_MUX_SLEEP_N: R2052.2, U2010.4 (SLP_S0#)
/Power Inputs/PD2_MUX_SSEQ1: R2051.1, U2010.2 (SSEQ1/A1)
/Power Inputs/PD2_MUX_VIO: R2049.1, U2010.14 (VIO_SEL)
/Power Inputs/PD2_PPHV: C2068.1, C2069.1, C2090.1, R2090.1, U42.20 (PPHV_(20-22)), U721.1 (IN), U721.2 (IN), U721.5 (IN_SYS)
/Power Inputs/PD2_RX1_N: D2125.1 (IO), J11.B10 (RX1-), U2010.31 (CRX1n)
/Power Inputs/PD2_RX1_P: D2124.1 (IO), J11.B11 (RX1+), U2010.30 (CRX1p)
/Power Inputs/PD2_RX2_N: D2127.1 (IO), J11.A10 (RX2-), U2010.36 (CRX2n)
/Power Inputs/PD2_RX2_P: D2126.1 (IO), J11.A11 (RX2+), U2010.37 (CRX2p)
/Power Inputs/PD2_SEL_FET_COMMON: C2145.1, Q17.2 (S), Q17.3 (S), Q17.4 (S), Q18.2 (S), Q18.3 (S), Q18.4 (S), U14.12 (VS2)
/Power Inputs/PD2_SEL_GATE: Q17.1 (G), Q18.1 (G), U14.11 (G2)
/Power Inputs/PD2_SEL_OV: R2144.2, R2145.1, U14.5 (OV2)
/Power Inputs/PD2_SEL_UV: R2143.2, R2144.1, U14.4 (UV2)
/Power Inputs/PD2_SSRX_RAW_N: C2050.1, U2010.18 (SSRXn)
/Power Inputs/PD2_SSRX_RAW_P: C2049.1, U2010.19 (SSRXp)
/Power Inputs/PD2_TX1_N: C2052.2, D2121.1 (IO), J11.A3 (TX1-)
/Power Inputs/PD2_TX1_P: C2051.2, D2120.1 (IO), J11.A2 (TX1+)
/Power Inputs/PD2_TX2_N: C2054.2, D2123.1 (IO), J11.B3 (TX2-)
/Power Inputs/PD2_TX2_P: C2053.2, D2122.1 (IO), J11.B2 (TX2+)
/Power Inputs/PD2_USB2_OE_N: Q2002.3 (D), R2056.2, U2013.9 (~OE)
/Power Inputs/PD2_VBUS_GATED: C2091.1, C2144.1, D2090.1 (K), Q17.5 (D(5-8)), R2143.1, U14.16 (V2), U721.17 (OUT), U721.18 (OUT)
/Power Inputs/PD_SEL_INTVCC: C2140.1, U14.8 (INTVCC), U14.18 (EN), U14.19 (~SHDN)
/Power Inputs/PD_SEL_TMR: C2141.1, U14.1 (TMR)
/SYS_3V3: C2003.1, C2004.1, C2005.1, C2006.1, C2007.1, C2008.1, C2030.1, C2043.1, C2044.1, C2045.1, C2046.1, C2047.1, C2048.1, C2070.1, R2006.1, R2007.1, R2012.1, R2016.1, R2046.1, R2047.1, R2052.1, R2056.1, U2000.1 (VCC), U2000.6 (VCC), U2000.20 (VCC), U2000.28 (VCC), U2003.10 (VCC), U2004.5 (VCC), U2006.5 (VCC), U2010.1 (VCC), U2010.6 (VCC), U2010.20 (VCC), U2010.28 (VCC), U2013.10 (VCC), U2014.5 (VCC), U2016.5 (VCC); also elsewhere on the board
/USBC1_DM: U2003.8 (D1-); also elsewhere on the board
/USBC1_DP: U2003.2 (D1+); also elsewhere on the board
/USBC1_SSRX_N: C2010.2; also elsewhere on the board
/USBC1_SSRX_P: C2009.2; also elsewhere on the board
/USBC1_SSTX_N: U2000.15 (SSTXn); also elsewhere on the board
/USBC1_SSTX_P: U2000.16 (SSTXp); also elsewhere on the board
/USB_PD_SELECTED: C2146.1, Q16.5 (D(5-8)), Q18.5 (D(5-8)), U14.15 (VOUT); also elsewhere on the board
/USB_PORT_5V: C2025.1, C2026.1, C2027.1, C2065.1, C2066.1, C2067.1, U41.34 (PP5V_(34-35)), U42.34 (PP5V_(34-35)); also elsewhere on the board
GND: C2000.2, C2001.2, C2002.2, C2003.2, C2004.2, C2005.2, C2006.2, C2007.2, C2008.2, C2015.2, C2016.2, C2017.2, C2018.2, C2019.2, C2020.2, C2021.2, C2022.2, C2023.2, C2024.2, C2025.2, C2026.2, C2027.2, C2028.2, C2029.2, C2030.2, C2040.2, C2041.2, C2042.2, C2043.2, C2044.2, C2045.2, C2046.2, C2047.2, C2048.2, C2055.2, C2056.2, C2057.2, C2058.2, C2059.2, C2060.2, C2061.2, C2062.2, C2063.2, C2064.2, C2065.2, C2066.2, C2067.2, C2068.2, C2069.2, C2070.2, C2080.2, C2081.2, C2082.2, C2090.2, C2091.2, C2092.2, C2140.2, C2141.2, C2142.2, C2143.2, C2144.2, C2145.2, C2146.2, D2080.2 (A), D2090.2 (A), D2100.2 (IO), D2101.2 (IO), D2102.2 (IO), D2103.2 (IO), D2104.2 (IO), D2105.2 (IO), D2106.2 (IO), D2107.2 (IO), D2120.2 (IO), D2121.2 (IO), D2122.2 (IO), D2123.2 (IO), D2124.2 (IO), D2125.2 (IO), D2126.2 (IO), D2127.2 (IO), J11.A1 (GND), J11.A12 (GND), J11.B1 (GND), J11.B12 (GND), J11.SH (SHIELD), J21.A1 (GND), J21.A12 (GND), J21.B1 (GND), J21.B12 (GND), J21.SH (SHIELD), Q2001.2 (S), Q2002.2 (S), R2008.2, R2009.2, R2010.2, R2011.2, R2013.2, R2014.2, R2018.2, R2048.2, R2049.2, R2050.2, R2051.2, R2053.2, R2054.2, R2058.2, R2082.2, R2083.2, R2084.2, R2092.2, R2093.2, R2094.2, R2142.2, R2145.2, U14.7 (GND), U14.20 (HYS), U14.21 (EP/GND), U41.3 (ADCIN2), U41.5 (GPIO0/LD1), U41.6 (GPIO1), U41.7 (GPIO2/LD2), U41.11 (GND), U41.12 (GND), U41.13 (GPIO11), U41.14 (GND), U41.19 (GPIO3), U41.27 (GPIO5/USB_N), U41.31 (GND), U41.39 (GND), U42.2 (ADCIN1), U42.3 (ADCIN2), U42.5 (GPIO0/LD1), U42.6 (GPIO1), U42.7 (GPIO2/LD2), U42.11 (GND), U42.12 (GND), U42.13 (GPIO11), U42.14 (GND), U42.19 (GPIO3), U42.27 (GPIO5/USB_N), U42.31 (GND), U42.39 (GND), U720.8 (GND), U720.11 (MODE), U720.15 (PGTH), U720.25 (GND), U721.8 (GND), U721.11 (MODE), U721.15 (PGTH), U721.25 (GND), U2000.22 (AEQENZ/SDA), U2000.27 (TEST1), U2000.41 (GND), U2001.8 (GND), U2001.13 (GND), U2001.18 (GND), U2001.21 (GND), U2002.1 (A0), U2002.2 (A1), U2002.3 (A2), U2002.4 (GND), U2002.7 (WP), U2003.1 (S), U2003.5 (GND), U2004.2 (GND), U2005.1 (GND), U2005.2 (GND), U2005.3 (GND), U2005.7 (GND), U2006.3 (GND), U2010.22 (AEQENZ/SDA), U2010.27 (TEST1), U2010.41 (GND), U2011.8 (GND), U2011.13 (GND), U2011.18 (GND), U2011.21 (GND), U2012.1 (A0), U2012.2 (A1), U2012.3 (A2), U2012.4 (GND), U2012.7 (WP), U2013.1 (S), U2013.5 (GND), U2014.2 (GND), U2015.1 (GND), U2015.2 (GND), U2015.3 (GND), U2015.7 (GND), U2016.3 (GND); also elsewhere on the board

Notes on the sheet:
Five-port source budget: 5 x 0.9A maximum advertised load = 4.5A on the dedicated 6A USB_PORT_5V rail.
== J21: USB 3.2 Gen 2 data plus USB-PD charging, side port 1 ==
== Two rear USB-C data/charging ports: J21 left and J11 right ==
The EC reads each TPS25751A contract first, programs the BQ25798 input limit, then enables exactly one default-off TPS26630 path.
J21: EEPROM configures DRP prefer-sink, 15V/3A sink, 5V/0.9A source, default Rp, GPIO6 FLIP, GPIO4 DFP, and GPIO7 data-attached.
GPIO4 AND GPIO7 qualifies both host USB2 and SuperSpeed. They remain disconnected through reset, detach, and sink-only operation.
LTC4418 independently validates approximately 13.1V to 17.1V and prevents either attached adapter from backfeeding the other.
Both ports carry USB 3.2 Gen 2 plus USB2 and can sink negotiated 15V or source protected default USB current.
TPS25751A loads a versioned 32KB EEPROM image while powered from dead-battery VBUS; no EC is needed to obtain the first 15V contract.
== J11: USB 3.2 Gen 2 data plus USB-PD charging, side port 2 ==
J11: EEPROM configures DRP prefer-sink, 15V/3A sink, 5V/0.9A source, default Rp, GPIO6 FLIP, GPIO4 DFP, and GPIO7 data-attached.
The raw 5V attach rail stays below the Type-C pre-attach capacitance limit; large sink bulk is behind the integrated PD switch.
== U14: two-input qualified PD selector; J21 has priority over J11 ==
Firmware must reject any configuration that advertises more than default USB current and must shed optional ports on rail fault.

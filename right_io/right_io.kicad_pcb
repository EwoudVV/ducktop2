# Repository EwoudVV/ducktop2 (continued)

## KiCad design left_io/left_io.kicad_pcb

Schematic: left_usb.kicad_sch

Parts:
C1705: 120p core feed-forward; C_0402_1005Metric; MPN GRM1555C1H121JA01D
C1706: 4.7u core input; C_0805_2012Metric; MPN GRM21BR71A475KA73L
C1707: 100n core input HF; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1708, C1709: 10u core output; C_0805_2012Metric; MPN GRM21BR71A106KE51L
C1710: 47n 25V USB5 bootstrap; C_0402_1005Metric; MPN GRM155R71E473KA88D
C1711, C1712: 10u 50V USB5 input; C_1206_3216Metric; MPN CGA5L1X7R1H106K160AC
C1713, C1867: 100n 50V USB5 input HF; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1714, C1715, C1868, C1869: 22u 25V USB5 output; TI characterized part; C_1210_3225Metric; MPN GRM32ER71E226KE15L
C1716: 100n oscillator bypass; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1717: 100n hub reset-gate bypass; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1722, C1723, C1724, C1725, C1728, C1729: 100n USB 3.2 TX AC coupling; C_0402_1005Metric; MPN GRM155R71C104KA88D
C1740, C1780: 100n branch input; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1741, C1781: 100n TPS25810 IN HF; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1742, C1782: 150u 10V TPS25810 input reservoir; CP_EIA-7343-31_Kemet-D; MPN T520D157M010ATE025
C1743, C1783: 10u protected VBUS_SYS; C_1206_3216Metric; MPN GRM31CR71A106KA01L
C1744, C1784: 100n TPS25810 AUX; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1745, C1746, C1747, C1785, C1786, C1787: 100n mux VDD; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1748, C1788: 1u mux local bulk; C_0603_1608Metric; MPN GRM188R71A105KA61D
C1749, C1789: 10n mux HF; C_0402_1005Metric; MPN GRM155R71H103KA88D
C1750, C1790: 1u 50V connector-side VBUS; C_0805_2012Metric; MPN GRM21BR71H105KA12L
C1751, C1791: 1u TPD1S514 VBUS_POWER stability; C_0603_1608Metric; MPN GRM188R71A105KA61D
C1810, C1811, C1812, C1813, C1814, C1815, C1816, C1817: 100n USB7206C VDD33 local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1820, C1821, C1822, C1823, C1824, C1825, C1826, C1827, C1828: 100n USB7206C VCORE local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1830, C1831, C1832, C1833, C1834, C1835, C1836, C1837: 1n USB7206C VDD33 HF; C_0402_1005Metric; MPN GRM155R71H102KA01D
C1840, C1841, C1842, C1843, C1844, C1845, C1846, C1847, C1848: 1n USB7206C VCORE HF; C_0402_1005Metric; MPN GRM155R71H102KA01D
C1849: 10u USB7206C VDD33 bulk; C_0805_2012Metric; MPN GRM21BR71A106KE51L
C1850: 10u 10V USB3-A VBUS bulk; C_0805_2012Metric; MPN GRM21BR71A106KA73L
C1851: 100n USB3-A VBUS HF; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1852: 100n 16V X7R USB3-A SSTX+ series AC; C_0402_1005Metric; MPN GRM155R71C104KA88D
C1853: 100n 16V X7R USB3-A SSTX- series AC; C_0402_1005Metric; MPN GRM155R71C104KA88D
C1854: 10u 10V USB2-A VBUS bulk; C_0805_2012Metric; MPN GRM21BR71A106KA73L
C1855: 100n USB2-A VBUS HF; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1860: 22u 25V USB5 VCC; effective minimum 4.7u; C_1210_3225Metric; MPN GRM32ER71E226KE15L
C1861: 100n 50V USB5 VDDA; C_0603_1608Metric; MPN GRM188R71H104KA93D
C1862: 220n 50V X7R USB5 COMP; C_0603_1608Metric; MPN C0603C224K5RACTU
C1863: 2.2n 50V C0G USB5 COMP HF; C_0603_1608Metric; MPN C0603C222J5GACTU
C1864, C1865: 330u 10V USB5 local reservoir; 4.3mm max height; CP_EIA-7343-43_Kemet-X; MPN T520X337M010ATE010
C1866: DNP 68u 25V input damping option; CP_EIA-7343-20_Kemet-V; MPN T521V686M025ATE050; not fitted
C2400, C2401, C2402, C2405, C2406, C2407, C2408, C2410, C2411, C2415: 100n; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2683: 1u 50V U1800 input bypass; C_0603_1608Metric; MPN GRT188R61H105ME13D
C2684: 1u 50V U1803 input bypass; C_0603_1608Metric; MPN GRT188R61H105ME13D
D1800, D1801, D1802, D1803, D1804, D1805, D1806, D1807, D1808, D1809, D1810, D1811, D1812, D1813, D1814, D1815: TPD1E0B04DPLR 0.13pF USB3 ESD; D_0201_0603Metric; MPN TPD1E0B04DPLR
J22: USB-C source-only data port J22; USB_C_Receptacle_Molex_105450-0101; MPN 105450-0101
J23: USB-C source-only data port J23; USB_C_Receptacle_Molex_105450-0101; MPN 105450-0101
J24: USB 3.0 Type-A internal header (hub DIS5); USB_A_Receptacle_XKB_U231-091N-4BLRA00-S; MPN U231-091N-4BLRA00-S
J25: USB 2.0 Type-A internal header (hub DIS6); USB_A_Receptacle_GCT_USB1046; MPN USB1046-GF-L
L1700: 470nH >=3.9A USB hub core; TDK_TFM201610; MPN TFM201610ALMA-R47MTAA
L1701: 6.8uH 18.4A Isat30 / 10.9A Irms20; Coilcraft_XGL1060; MPN XGL1060-682MEC
R1700: 10k CFG_STRAP1; R_0603_1608Metric; MPN RC0603FR-0710KL
R1701: 200k CFG_STRAP2; R_0603_1608Metric; MPN RC0603FR-07200KL
R1702: 200k CFG_STRAP3; R_0603_1608Metric; MPN RC0603FR-07200KL
R1703: 200k all ports removable; R_0603_1608Metric; MPN RC0603FR-07200KL
R1704: 200k BC1.2 disabled; R_0603_1608Metric; MPN RC0603FR-07200KL
R1705: 91.0k 0.02% 5ppm core FB top; R_0603_1608Metric; MPN TNPU060391K0HZEN00
R1706: 100k 0.02% 5ppm core FB bottom; R_0603_1608Metric; MPN TNPU0603100KHZEN00
R1707: 100k core PG pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R1708: 12.0k 1% USB7206C RBIAS; R_0603_1608Metric; MPN RC0603FR-0712KL
R1710: 100k USB5 hardware-qualified EN top; R_0603_1608Metric; MPN RC0603FR-07100KL
R1711: 100k USB5 EN bottom; R_0603_1608Metric; MPN RC0603FR-07100KL
R1712: 55.6k 0.02% 5ppm USB5 FB top; R_0603_1608Metric; MPN TNPU060355K6HZEN00
R1713: 10.2k 0.02% 5ppm USB5 FB bottom; R_0603_1608Metric; MPN TNPU060310K2HZEN00
R1714: 100k USB5 PG pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R1715, R1716, R1717: 10k TEST pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R1718: 10k hub 3V3 supervisor pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R1720, R1721, R1722, R1723: 100k unused SPI pull-down; R_0603_1608Metric; MPN RC0603FR-07100KL
R1740, R1780: 19.1k 1% TPS2553 VBUS plus VCONN ILIM; R_0603_1608Metric; MPN RC0603FR-0719K1L
R1741, R1781: 4.99k POL pull-up; R_0603_1608Metric; MPN RC0603FR-074K99L
R1742, R1782: 100k 1% TPS25810 REF; R_0603_1608Metric; MPN RC0603FR-07100KL
R1750, R1790: 249R 0.25W TPS25810 OUT discharge; R_1206_3216Metric; MPN RC1206FR-07249RL
R1840: 10k DS1 PRT_CTL idle pull-up; VBUS is managed by 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; R_0603_1608Metric; MPN RC0603FR-0710KL
R1841: 10k DS4 PRT_CTL idle pull-up (J12 branch enable, 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; R_0603_1608Metric; MPN RC0603FR-0710KL
R1850, R1851: 20.0k 1% TPS2553 1.3A ILIM; R_0603_1608Metric; MPN RC0603FR-0720KL
R1860: 22.1k 0.02% 5ppm USB5 RT; R_0603_1608Metric; MPN TNPU060322K1HZEN00
R1861: 29.4k 1% standalone DRSS off; R_0603_1608Metric; MPN RC0603FR-0729K4L
R1862: 2.49k 0.02% 5ppm USB5 COMP; R_0603_1608Metric; MPN TNPU06032K49HZEN00
R1863: 1R USB5 bootstrap damping; R_0603_1608Metric; MPN RC0603FR-071RL
R2400, R2401, R2402, R2412, R2429: 10k; R_0603_1608Metric; MPN RC0603FR-0710KL
R2405, R2406, R2407, R2408, R2410, R2420, R2421, R2422, R2423, R2426, R2427: 100k; R_0603_1608Metric; MPN RC0603FR-07100KL
R2424, R2425: 12.7k 1%; R_0603_1608Metric; MPN RC0603FR-0712K7L
RS1860, RS1861: 10mOhm 1% 1W USB5 sense; parallel pair gives 5mOhm; Panasonic_ERJ8CW_10to16m; MPN ERJ8CWFR010V
U1700: USB7206C-I/KDX six-port USB 3.2 Gen 2 hub; VQFN-100-1EP_12x12mm_P0.4mm_EP8x8mm_ThermalVias; MPN USB7206C-I/KDX
U1701: TPS62823DLC 3A USB7206C 1.146V core buck; Texas_VSON-HR-8_1.5x2mm_P0.5mm; MPN TPS62823DLC
U1702: TLV803EA29 USB hub reset supervisor; SOT-23-3; MPN TLV803EA29RDBZR
U1703: LM706A0RRXR USB5 5.161V; 6.5A design envelope; Texas_RRX0029B_VQFN-29_6x6mm; MPN LM706A0RRXR
U1704: SN74LVC1G08 hub 3V3/core-PG reset gate; SOT-23-5; MPN SN74LVC1G08DBVR
U1740, U1780: TPS2553DDBVR 1.3A USB branch; SOT-23-6; MPN TPS2553DDBVR
U1741, U1781: TPS25810RVCR Type-C DFP controller; Texas_RVC0020A_WQFN-20-1EP_3x4mm_P0.5mm_EP1.6x2.6mm; MPN TPS25810RVCR
U1742, U1782: HD3SS6126RUAR USB3 orientation mux; WQFN-42-1EP_3.5x9mm_P0.5mm_EP2.05x7.55mm_ThermalVias; MPN HD3SS6126RUAR
U1743, U1783: TPD1S514-1YZR 5.9V VBUS OVP; Texas_TPD1S514_YZ0012_1.99x1.29mm_P0.4mm; MPN TPD1S514-1YZR
U1745, U1785: TPD4E05U06 USB2/CC ESD; USON-10_2.5x1.0mm_P0.5mm; MPN TPD4E05U06DQAR
U1800: TPS2553DDBVR USB3-A VBUS branch 1.3A; SOT-23-6; MPN TPS2553DDBVR
U1801: USBLC6-2P6 USB3-A D+/D- ESD; SOT-666; MPN USBLC6-2P6
U1802: TPD4E05U06 USB3-A SuperSpeed ESD; USON-10_2.5x1.0mm_P0.5mm; MPN TPD4E05U06DQAR
U1803: TPS2553DDBVR USB2-A VBUS branch 1.3A; SOT-23-6; MPN TPS2553DDBVR
U1804: USBLC6-2P6 USB2-A D+/D- ESD; SOT-666; MPN USBLC6-2P6
U2400: TCA9539PWR USB permissions @0x76; TSSOP-24_4.4x7.8mm_P0.65mm; MPN TCA9539PWR
U2401: INA226AIDGSR USB5 monitor @0x40; TSSOP-10_3x3mm_P0.5mm; MPN INA226AIDGSR
U2402: SN74LVC1G74DCUR USB fault latch; TI_DCU0008A_VSSOP8; MPN SN74LVC1G74DCUR
U2405: SN74LVC1G08DBVR J22 source permission; SOT-23-5; MPN SN74LVC1G08DBVR
U2406: SN74LVC1G08DBVR J23 source permission; SOT-23-5; MPN SN74LVC1G08DBVR
U2407: SN74LVC1G08DBVR J24 source permission; SOT-23-5; MPN SN74LVC1G08DBVR
U2408: SN74LVC1G08DBVR J25 source permission; SOT-23-5; MPN SN74LVC1G08DBVR
U2410: SN74LVC1G11DCKR USB5 permit AND; SOT-363_SC-70-6; MPN SN74LVC1G11DCKR
U2411: SN74LVC1G08DBVR raw fault veto; SOT-23-5; MPN SN74LVC1G08DBVR
U2413: SN74LVC1G08DBVR raw OC and SYS5 veto; SOT-23-5; MPN SN74LVC1G08DBVR
Y1700: 25.000MHz 3.3V USB hub oscillator; Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm; MPN ASDMB-25.000MHZ-LC-T

Connections:
/HUB_DS1_DN: U1700.6 (DM1); also elsewhere on the board
/HUB_DS1_DP: U1700.5 (DP1); also elsewhere on the board
/HUB_DS4_DN: U1700.35 (DM4); also elsewhere on the board
/HUB_DS4_DP: U1700.34 (DP4); also elsewhere on the board
/HUB_PRT_CTL4: R1841.2, U1700.57 (PF14); also elsewhere on the board
/INTERNAL_USB_VBUS_VALID: R2426.1, U1700.2 (PF30/VBUS_DET), U2400.19 (IO1_6), U2407.2, U2408.2, U2413.2; also elsewhere on the board
/MCU_3V3: C2400.1, C2401.1, C2402.1, C2405.1, C2406.1, C2407.1, C2408.1, C2410.1, C2411.1, C2415.1, R2401.1, R2402.1, U2400.2 (A1), U2400.24 (V_{DD}), U2401.6 (VS), U2402.8 (VCC), U2405.5 (VCC), U2406.5 (VCC), U2407.5 (VCC), U2408.5 (VCC), U2410.5 (VCC), U2411.5 (VCC), U2413.5 (VCC); also elsewhere on the board
/PD1_I2C_SCL: U2400.22 (SCL), U2401.5 (SCL); also elsewhere on the board
/PD1_I2C_SDA: U2400.23 (SDA), U2401.4 (SDA); also elsewhere on the board
/PD1_SOURCE_PG: R2424.1, U2400.17 (IO1_4); also elsewhere on the board
/PD2_SOURCE_PG: R2425.1, U2400.18 (IO1_5); also elsewhere on the board
/SERVICE_MUX_RESET_N: R2420.1, U2400.3 (~RESET); also elsewhere on the board
/SYS_3V3: C1706.1, C1707.1, C1716.1, C1717.1, C1744.1, C1745.1, C1746.1, C1747.1, C1748.1, C1749.1, C1784.1, C1785.1, C1786.1, C1787.1, C1788.1, C1789.1, C1810.1, C1811.1, C1812.1, C1813.1, C1814.1, C1815.1, C1816.1, C1817.1, C1830.1, C1831.1, C1832.1, C1833.1, C1834.1, C1835.1, C1836.1, C1837.1, C1849.1, R1707.1, R1714.1, R1715.1, R1716.1, R1717.1, R1718.1, R1741.1, R1781.1, R1840.1, R1841.1, R2412.1, U1700.26 (VDD33), U1700.43 (VDD33), U1700.53 (VDD33), U1700.62 (VDD33), U1700.67 (VDD33), U1700.79 (VDD33), U1700.88 (VDD33), U1700.99 (VDD33), U1701.1 (EN), U1701.7 (VIN), U1702.3 (VDD), U1704.5 (VCC), U1741.5 (AUX), U1742.13 (VDD), U1742.20 (VDD), U1742.30 (VDD), U1781.5 (AUX), U1782.13 (VDD), U1782.20 (VDD), U1782.30 (VDD), U2410.6, Y1700.1 (Standby), Y1700.4 (VDD); also elsewhere on the board
/USB Hub + Ports/HUB_3V3_OK: R1718.2, U1702.1 (RESETz), U1704.1
/USB Hub + Ports/HUB_BC_EN: R1704.1, U1700.70 (SPI_D0/CFG_BC_EN/PF22)
/USB Hub + Ports/HUB_CFG1: R1700.1, U1700.21 (CFG_STRAP1)
/USB Hub + Ports/HUB_CFG2: R1701.1, U1700.22 (CFG_STRAP2)
/USB Hub + Ports/HUB_CFG3: R1702.1, U1700.23 (CFG_STRAP3)
/USB Hub + Ports/HUB_CLK: U1700.98 (XTALI/CLK_IN), Y1700.3 (Out)
/USB Hub + Ports/HUB_CORE_FB: C1705.2, R1705.2, R1706.1, U1701.2 (FB)
/USB Hub + Ports/HUB_CORE_PG: R1707.2, U1701.8 (PG), U1704.2
/USB Hub + Ports/HUB_CORE_SW: L1700.1, U1701.6 (SW)
/USB Hub + Ports/HUB_DIS5_DN: J24.2 (D-), U1700.82 (DM5), U1801.3 (I/O2), U1801.4 (I/O2)
/USB Hub + Ports/HUB_DIS5_DP: J24.3 (D+), U1700.81 (DP5), U1801.1 (I/O1), U1801.6 (I/O1)
/USB Hub + Ports/HUB_DIS5_RX_N: J24.5 (StdA_SSRX-), U1700.87 (RXDM5), U1802.5 (D2-)
/USB Hub + Ports/HUB_DIS5_RX_P: J24.6 (StdA_SSRX+), U1700.86 (RXDP5), U1802.4 (D2+)
/USB Hub + Ports/HUB_DIS5_TX_N: C1853.1, U1700.84 (TXDM5), U1802.2 (D1-)
/USB Hub + Ports/HUB_DIS5_TX_P: C1852.1, U1700.83 (TXDP5), U1802.1 (D1+)
/USB Hub + Ports/HUB_DIS6_DN: J25.2 (D-), U1700.41 (DM6), U1804.3 (I/O2), U1804.4 (I/O2)
/USB Hub + Ports/HUB_DIS6_DP: J25.3 (D+), U1700.42 (DP6), U1804.1 (I/O1), U1804.6 (I/O1)
/USB Hub + Ports/HUB_DS1_PRT_CTL: R1840.2, U1700.60 (PF17)
/USB Hub + Ports/HUB_DS2_DN: J22.A7 (D-), J22.B7 (D-), U1700.15 (DM2), U1785.2 (D1-)
/USB Hub + Ports/HUB_DS2_DP: J22.A6 (D+), J22.B6 (D+), U1700.14 (DP2), U1785.1 (D1+)
/USB Hub + Ports/HUB_DS2_SSRX_N: U1700.20 (RXDM2), U1782.16 (SSA1(n))
/USB Hub + Ports/HUB_DS2_SSRX_P: U1700.19 (RXDP2), U1782.15 (SSA1(p))
/USB Hub + Ports/HUB_DS2_SSTX_N: C1723.2, U1782.12 (SSA0(n))
/USB Hub + Ports/HUB_DS2_SSTX_P: C1722.2, U1782.11 (SSA0(p))
/USB Hub + Ports/HUB_DS2_TX_RAW_N: C1723.1, U1700.17 (TXDM2)
/USB Hub + Ports/HUB_DS2_TX_RAW_P: C1722.1, U1700.16 (TXDP2)
/USB Hub + Ports/HUB_DS3_DN: J23.A7 (D-), J23.B7 (D-), U1700.28 (DM3), U1745.2 (D1-)
/USB Hub + Ports/HUB_DS3_DP: J23.A6 (D+), J23.B6 (D+), U1700.27 (DP3), U1745.1 (D1+)
/USB Hub + Ports/HUB_DS3_SSRX_N: U1700.33 (RXDM3), U1742.16 (SSA1(n))
/USB Hub + Ports/HUB_DS3_SSRX_P: U1700.32 (RXDP3), U1742.15 (SSA1(p))
/USB Hub + Ports/HUB_DS3_SSTX_N: C1725.2, U1742.12 (SSA0(n))
/USB Hub + Ports/HUB_DS3_SSTX_P: C1724.2, U1742.11 (SSA0(p))
/USB Hub + Ports/HUB_DS3_TX_RAW_N: C1725.1, U1700.30 (TXDM3)
/USB Hub + Ports/HUB_DS3_TX_RAW_P: C1724.1, U1700.29 (TXDP3)
/USB Hub + Ports/HUB_NON_REM: R1703.1, U1700.69 (SPI_CE_N/CFG_NON_REM/PF20)
/USB Hub + Ports/HUB_PRT_CTL2: U1700.59 (PF16), U1780.4 (~FAULT), U1781.1 (~FAULT), U2405.2
/USB Hub + Ports/HUB_PRT_CTL3: U1700.58 (PF15), U1740.4 (~FAULT), U1741.1 (~FAULT), U2406.2
/USB Hub + Ports/HUB_RBIAS: R1708.1, U1700.100 (RBIAS)
/USB Hub + Ports/HUB_RESET_N: U1700.1 (RESET_N), U1704.4
/USB Hub + Ports/HUB_SPI_CLK: R1720.1, U1700.68 (SPI_CLK/PF21)
/USB Hub + Ports/HUB_SPI_D1: R1721.1, U1700.71 (SPI_D1/PF23)
/USB Hub + Ports/HUB_SPI_D2: R1722.1, U1700.72 (SPI_D2/PF24)
/USB Hub + Ports/HUB_SPI_D3: R1723.1, U1700.73 (SPI_D3/PF25)
/USB Hub + Ports/HUB_TEST1: R1715.2, U1700.63 (TEST1)
/USB Hub + Ports/HUB_TEST2: R1716.2, U1700.64 (TEST2)
/USB Hub + Ports/HUB_TEST3: R1717.2, U1700.65 (TEST3)
/USB Hub + Ports/HUB_UP_TX_RAW_N: C1729.1, U1700.92 (USB3UP_TXDM)
/USB Hub + Ports/HUB_UP_TX_RAW_P: C1728.1, U1700.91 (USB3UP_TXDP)
/USB Hub + Ports/HUB_VCORE: C1705.1, C1708.1, C1709.1, C1820.1, C1821.1, C1822.1, C1823.1, C1824.1, C1825.1, C1826.1, C1827.1, C1828.1, C1840.1, C1841.1, C1842.1, C1843.1, C1844.1, C1845.1, C1846.1, C1847.1, C1848.1, L1700.2, R1705.1, U1700.9 (VCORE), U1700.18 (VCORE), U1700.25 (VCORE), U1700.31 (VCORE), U1700.38 (VCORE), U1700.55 (VCORE), U1700.78 (VCORE), U1700.85 (VCORE), U1700.93 (VCORE)
/USB Hub + Ports/J22_5V_PRE: C1781.1, C1782.1, U1780.6 (OUT), U1781.2 (IN1), U1781.3 (IN1), U1781.4 (IN2)
/USB Hub + Ports/J22_CC1: J22.A5 (CC1), U1781.11 (CC1), U1785.4 (D2+)
/USB Hub + Ports/J22_CC2: J22.B5 (CC2), U1781.13 (CC2), U1785.5 (D2-)
/USB Hub + Ports/J22_ILIM: R1780.1, U1780.5 (ILIM)
/USB Hub + Ports/J22_POL_N: R1781.2, U1781.18 (~POL), U1782.9 (SEL)
/USB Hub + Ports/J22_REF: R1782.1, U1781.10 (REF)
/USB Hub + Ports/J22_REF_RTN: R1782.2, U1781.9 (REF_RTN)
/USB Hub + Ports/J22_RX1_N: D1805.1 (IO), J22.B10 (RX1-), U1782.22 (SSC1(n))
/USB Hub + Ports/J22_RX1_P: D1804.1 (IO), J22.B11 (RX1+), U1782.23 (SSC1(p))
/USB Hub + Ports/J22_RX2_N: D1807.1 (IO), J22.A10 (RX2-), U1782.26 (SSB1(n))
/USB Hub + Ports/J22_RX2_P: D1806.1 (IO), J22.A11 (RX2+), U1782.27 (SSB1(p))
/USB Hub + Ports/J22_TX1_N: D1801.1 (IO), J22.A3 (TX1-), U1782.24 (SSC0(n))
/USB Hub + Ports/J22_TX1_P: D1800.1 (IO), J22.A2 (TX1+), U1782.25 (SSC0(p))
/USB Hub + Ports/J22_TX2_N: D1803.1 (IO), J22.B3 (TX2-), U1782.28 (SSB0(n))
/USB Hub + Ports/J22_TX2_P: D1802.1 (IO), J22.B2 (TX2+), U1782.29 (SSB0(p))
/USB Hub + Ports/J22_VBUS: C1790.1, J22.A4 (VBUS), J22.A9 (VBUS), J22.B4 (VBUS), J22.B9 (VBUS), U1783.B3 (VBUS_CON), U1783.C2 (VBUS_CON), U1783.C3 (VBUS_CON)
/USB Hub + Ports/J22_VBUS_POWER: C1791.1, U1783.B1 (VBUS_POWER)
/USB Hub + Ports/J22_VBUS_SYS: C1783.1, R1790.1, U1781.14 (OUT), U1781.15 (OUT), U1783.A2 (VBUS_SYS), U1783.A3 (VBUS_SYS), U1783.B2 (VBUS_SYS)
/USB Hub + Ports/J23_5V_PRE: C1741.1, C1742.1, U1740.6 (OUT), U1741.2 (IN1), U1741.3 (IN1), U1741.4 (IN2)
/USB Hub + Ports/J23_CC1: J23.A5 (CC1), U1741.11 (CC1), U1745.4 (D2+)
/USB Hub + Ports/J23_CC2: J23.B5 (CC2), U1741.13 (CC2), U1745.5 (D2-)
/USB Hub + Ports/J23_ILIM: R1740.1, U1740.5 (ILIM)
/USB Hub + Ports/J23_POL_N: R1741.2, U1741.18 (~POL), U1742.9 (SEL)
/USB Hub + Ports/J23_REF: R1742.1, U1741.10 (REF)
/USB Hub + Ports/J23_REF_RTN: R1742.2, U1741.9 (REF_RTN)
/USB Hub + Ports/J23_RX1_N: D1813.1 (IO), J23.B10 (RX1-), U1742.22 (SSC1(n))
/USB Hub + Ports/J23_RX1_P: D1812.1 (IO), J23.B11 (RX1+), U1742.23 (SSC1(p))
/USB Hub + Ports/J23_RX2_N: D1815.1 (IO), J23.A10 (RX2-), U1742.26 (SSB1(n))
/USB Hub + Ports/J23_RX2_P: D1814.1 (IO), J23.A11 (RX2+), U1742.27 (SSB1(p))
/USB Hub + Ports/J23_TX1_N: D1809.1 (IO), J23.A3 (TX1-), U1742.24 (SSC0(n))
/USB Hub + Ports/J23_TX1_P: D1808.1 (IO), J23.A2 (TX1+), U1742.25 (SSC0(p))
/USB Hub + Ports/J23_TX2_N: D1811.1 (IO), J23.B3 (TX2-), U1742.28 (SSB0(n))
/USB Hub + Ports/J23_TX2_P: D1810.1 (IO), J23.B2 (TX2+), U1742.29 (SSB0(p))
/USB Hub + Ports/J23_VBUS: C1750.1, J23.A4 (VBUS), J23.A9 (VBUS), J23.B4 (VBUS), J23.B9 (VBUS), U1743.B3 (VBUS_CON), U1743.C2 (VBUS_CON), U1743.C3 (VBUS_CON)
/USB Hub + Ports/J23_VBUS_POWER: C1751.1, U1743.B1 (VBUS_POWER)
/USB Hub + Ports/J23_VBUS_SYS: C1743.1, R1750.1, U1741.14 (OUT), U1741.15 (OUT), U1743.A2 (VBUS_SYS), U1743.A3 (VBUS_SYS), U1743.B2 (VBUS_SYS)
/USB Hub + Ports/J24_5V_PRE: C1850.1, C1851.1, J24.1 (VBUS), U1800.6 (OUT), U1801.5 (VBUS)
/USB Hub + Ports/J24_ILIM: R1850.1, U1800.5 (ILIM)
/USB Hub + Ports/J24_SSTX_N: C1853.2, J24.8 (StdA_SSTX-)
/USB Hub + Ports/J24_SSTX_P: C1852.2, J24.9 (StdA_SSTX+)
/USB Hub + Ports/J25_5V_PRE: C1854.1, C1855.1, J25.1 (VBUS), U1803.6 (OUT), U1804.5 (VBUS)
/USB Hub + Ports/J25_ILIM: R1851.1, U1803.5 (ILIM)
/USB Hub + Ports/USB5_BOOT: R1863.1, U1703.4 (CBOOT)
/USB Hub + Ports/USB5_BOOT_C: C1710.1, R1863.2
/USB Hub + Ports/USB5_COMBINED_OK: R2429.1, U2402.7 (~PRE), U2411.2, U2413.4
/USB Hub + Ports/USB5_COMP: C1863.1, R1862.1, U1703.15 (EXTCOMP)
/USB Hub + Ports/USB5_COMP_RC: C1862.1, R1862.2
/USB Hub + Ports/USB5_CONFIG: R1861.1, U1703.13 (CONFIG)
/USB Hub + Ports/USB5_EN: R1710.2, R1711.1, U1703.9 (EN/UVLO)
/USB Hub + Ports/USB5_FAULT_CLEAR_N: R2402.2, U2400.13 (IO1_0), U2402.6 (~CLR)
/USB Hub + Ports/USB5_FAULT_N: R2421.1, U2400.14 (IO1_1), U2402.3 (~Q), U2410.3
/USB Hub + Ports/USB5_FB: R1712.2, R1713.1, U1703.16 (FB)
/USB Hub + Ports/USB5_HW_ENABLE: R1710.1, R2400.1, U2411.4
/USB Hub + Ports/USB5_LATCH_ENABLE: U2410.4, U2411.1
/USB Hub + Ports/USB5_OC_N: R2401.2, R2422.1, U2400.15 (IO1_2), U2401.3 (~Alert), U2413.1
/USB Hub + Ports/USB5_PERMIT: R2410.1, U2400.4 (IO0_0), U2410.1
/USB Hub + Ports/USB5_PG: R1714.2, R2412.2, R2423.1, U1703.7 (PG/SYNCOUT), U2400.16 (IO1_3)
/USB Hub + Ports/USB5_PRE_SENSE: L1701.2, RS1860.1, RS1861.1, U1703.11 (ISNS+), U2401.10 (Vin+)
/USB Hub + Ports/USB5_RT: R1860.1, U1703.14 (RT)
/USB Hub + Ports/USB5_SW: L1701.1, U1703.20 (SW1), U1703.21 (SW2), U1703.22 (SW3)
/USB Hub + Ports/USB5_SW_BOOT: C1710.2, U1703.5 (SW4)
/USB Hub + Ports/USB5_VCC: C1860.1, U1703.19 (VCC)
/USB Hub + Ports/USB5_VDDA: C1861.1, U1703.18 (VDDA)
/USB Hub + Ports/USB_IO_UNUSED7: R2427.1, U2400.20 (IO1_7)
/USB Hub + Ports/USB_J22_PERMIT: R2405.1, U2400.7 (IO0_3), U2405.1
/USB Hub + Ports/USB_J22_SWITCH_EN: U1780.3 (EN), U1781.6 (EN), U2405.4
/USB Hub + Ports/USB_J23_PERMIT: R2406.1, U2400.8 (IO0_4), U2406.1
/USB Hub + Ports/USB_J23_SWITCH_EN: U1740.3 (EN), U1741.6 (EN), U2406.4
/USB Hub + Ports/USB_J24_PERMIT: R2407.1, U2400.10 (IO0_6), U2407.1
/USB Hub + Ports/USB_J24_SWITCH_EN: U1800.3 (EN), U2407.4
/USB Hub + Ports/USB_J25_PERMIT: R2408.1, U2400.11 (IO0_7), U2408.1
/USB Hub + Ports/USB_J25_SWITCH_EN: U1803.3 (EN), U2408.4
/USBC2_DN: U1700.90 (USB2UP_DM); also elsewhere on the board
/USBC2_DP: U1700.89 (USB2UP_DP); also elsewhere on the board
/USBC2_SSRX_N: C1729.2; also elsewhere on the board
/USBC2_SSRX_P: C1728.2; also elsewhere on the board
/USBC2_SSTX_N: U1700.95 (USB3UP_RXDM); also elsewhere on the board
/USBC2_SSTX_P: U1700.94 (USB3UP_RXDP); also elsewhere on the board
/USB_J11_PERMIT: U2400.6 (IO0_2); also elsewhere on the board
/USB_J12_PERMIT: U2400.9 (IO0_5); also elsewhere on the board
/USB_J21_PERMIT: U2400.5 (IO0_1); also elsewhere on the board
/USB_PORT_5V: C1714.1, C1715.1, C1740.1, C1780.1, C1864.1, C1865.1, C1868.1, C1869.1, C2683.1, C2684.1, R1712.1, RS1860.2, RS1861.2, U1703.12 (VOUT), U1740.1 (IN), U1780.1 (IN), U1800.1 (IN), U1803.1 (IN), U2401.8 (Vbus), U2401.9 (Vin-); also elsewhere on the board
/VSYS: C1711.1, C1712.1, C1713.1, C1866.1, C1867.1, U1703.1 (VIN4), U1703.2 (VIN5), U1703.3 (VIN6), U1703.27 (VIN1), U1703.28 (VIN2), U1703.29 (VIN3); also elsewhere on the board
GND: C1706.2, C1707.2, C1708.2, C1709.2, C1711.2, C1712.2, C1713.2, C1714.2, C1715.2, C1716.2, C1717.2, C1740.2, C1741.2, C1742.2, C1743.2, C1744.2, C1745.2, C1746.2, C1747.2, C1748.2, C1749.2, C1750.2, C1751.2, C1780.2, C1781.2, C1782.2, C1783.2, C1784.2, C1785.2, C1786.2, C1787.2, C1788.2, C1789.2, C1790.2, C1791.2, C1810.2, C1811.2, C1812.2, C1813.2, C1814.2, C1815.2, C1816.2, C1817.2, C1820.2, C1821.2, C1822.2, C1823.2, C1824.2, C1825.2, C1826.2, C1827.2, C1828.2, C1830.2, C1831.2, C1832.2, C1833.2, C1834.2, C1835.2, C1836.2, C1837.2, C1840.2, C1841.2, C1842.2, C1843.2, C1844.2, C1845.2, C1846.2, C1847.2, C1848.2, C1849.2, C1850.2, C1851.2, C1854.2, C1855.2, C1860.2, C1861.2, C1862.2, C1863.2, C1864.2, C1865.2, C1866.2, C1867.2, C1868.2, C1869.2, C2400.2, C2401.2, C2402.2, C2405.2, C2406.2, C2407.2, C2408.2, C2410.2, C2411.2, C2415.2, C2683.2, C2684.2, D1800.2 (IO), D1801.2 (IO), D1802.2 (IO), D1803.2 (IO), D1804.2 (IO), D1805.2 (IO), D1806.2 (IO), D1807.2 (IO), D1808.2 (IO), D1809.2 (IO), D1810.2 (IO), D1811.2 (IO), D1812.2 (IO), D1813.2 (IO), D1814.2 (IO), D1815.2 (IO), J22.A1 (GND), J22.A12 (GND), J22.B1 (GND), J22.B12 (GND), J22.SH (SHIELD), J23.A1 (GND), J23.A12 (GND), J23.B1 (GND), J23.B12 (GND), J23.SH (SHIELD), J24.4 (GND), J24.7 (GND_DRAIN), J24.SH, J25.4 (GND), J25.SH (Shield), R1700.2, R1701.2, R1702.2, R1703.2, R1704.2, R1706.2, R1708.2, R1711.2, R1713.2, R1720.2, R1721.2, R1722.2, R1723.2, R1740.2, R1750.2, R1780.2, R1790.2, R1850.2, R1851.2, R1860.2, R1861.2, R2400.2, R2405.2, R2406.2, R2407.2, R2408.2, R2410.2, R2420.2, R2421.2, R2422.2, R2423.2, R2424.2, R2425.2, R2426.2, R2427.2, R2429.2, U1700.24 (TESTEN), U1700.101 (GND), U1701.3 (AGND), U1701.5 (PGND), U1702.2 (GND), U1703.6 (BIAS), U1703.8 (PFM/SYNCIN), U1703.17 (AGND), U1703.23 (PGND1), U1703.24 (PGND2), U1703.25 (PGND3), U1703.26 (PGND4), U1703.30 (PGND), U1704.3 (GND), U1740.2 (GND), U1741.7 (CHG), U1741.8 (CHG_HI), U1741.12 (GND), U1741.21 (GND), U1742.6 (HS_~OE), U1742.10 (GND), U1742.14 (GND), U1742.17 (GND), U1742.19 (GND), U1742.21 (GND), U1742.43 (EPAD), U1743.A1 (EN_N), U1743.A4 (GND), U1743.B4 (GND), U1743.C1 (GND), U1743.C4 (GND), U1745.3 (GND), U1745.8 (GND), U1780.2 (GND), U1781.7 (CHG), U1781.8 (CHG_HI), U1781.12 (GND), U1781.21 (GND), U1782.6 (HS_~OE), U1782.10 (GND), U1782.14 (GND), U1782.17 (GND), U1782.19 (GND), U1782.21 (GND), U1782.43 (EPAD), U1783.A1 (EN_N), U1783.A4 (GND), U1783.B4 (GND), U1783.C1 (GND), U1783.C4 (GND), U1785.3 (GND), U1785.8 (GND), U1800.2 (GND), U1801.2 (GND), U1802.3 (GND), U1802.8 (GND), U1803.2 (GND), U1804.2 (GND), U2400.12 (V_{SS}), U2400.21 (A0), U2401.1 (A1), U2401.2 (A0), U2401.7 (GND), U2402.1 (CLK), U2402.2 (D), U2402.4 (GND), U2405.3 (GND), U2406.3 (GND), U2407.3 (GND), U2408.3 (GND), U2410.2 (GND), U2411.3 (GND), U2413.3 (GND), Y1700.2 (GND); also elsewhere on the board

Notes on the sheet:
== Left I/O: USB7206C hub, source ports, USB-A spare ports ==
Board split Phase 2.1: hub + PD1 moved left; FPC-1 crosses to center.
== 6.5A USB5 converter envelope and 1.15V hub-core rail ==
USB5: external COMP 2.49k / 220n / 2.2n; include each PP5V reservoir gate state and remote cable R/L in the loop model.
6.5A includes VBUS and VCONN. Source admission, harness loss, capacitor corners, startup and thermal behavior require qualification.
== Internal USB-A spare ports: hub DIS5 (USB3) + DIS6 (USB2) ==
== J22: source-only USB-C data port, USB7206C downstream 2, USB3 ==
== J23: source-only USB-C data port, USB7206C downstream 3, USB3 ==
Raw OC and SYS5 veto remain active during clear; any SYS5 loss latches USB off until explicit clear.
USB permissions reset off; fault clear is active-low and defaults high.

Schematic: left_pd.kicad_sch

Parts:
C2000: 100n 100V TPD4S201 VBIAS; C_0805_2012Metric; MPN GRM21BR72A104KA01L
C2001: 820n 10V TPD4S201 VPWR; C_0805_2012Metric; MPN GRM21BR71A824KA01L
C2002: 100n EEPROM local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2003: 100n mux-control buffer local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2004: 10u TUSB1142 local; C_1206_3216Metric; MPN GRM31CR71A106KA01L
C2005, C2006, C2007, C2008: 100n TUSB1142 VCC local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2009, C2010, C2011, C2012, C2013, C2014: 220n USB3 TX AC coupling; C_0402_1005Metric; MPN GRM155R71C224KA12D
C2015: 4.7u 25V raw VBUS; pre-attach total below 10uF; C_1206_3216Metric; MPN GRM31CR71E475KA88L
C2016, C2017, C2018, C2019: 10n 50V connector VBUS HF; C_0402_1005Metric; MPN GRM155R71H103KA88D
C2020: 10u 25V X7R; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C2021, C2692: 4.7u 25V X7R; C_1206_3216Metric; MPN GRM31CR71E475KA88L
C2022: 10u 10V X7R; C_1206_3216Metric; MPN GRM31CR71A106KA01L
C2023, C2024: 270p C0G; C_0402_1005Metric; MPN GRM1555C1H271JA01D
C2025, C2026: 100u 10V PP5V source bulk; CP_EIA-7343-31_Kemet-D; MPN T520D107M010ATE070
C2027: 10u PP5V local ceramic; C_1206_3216Metric; MPN GRM31CR71A106KA01L
C2028: 68u 25V PPHV sink bulk; CP_EIA-7343-31_Kemet-D; MPN T521V686M025ATE050
C2029: 100n 50V PPHV local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2030: 100n USB2 switch local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2080: 100n 50V input local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2081: 10u 25V output; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C2082: 10n 50V C0G slew control; C_0603_1608Metric; MPN GRM1885C1H103JA01D
C2140: 100n selector INTVCC; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2141: 1n 50V C0G selector validation; C_0402_1005Metric; MPN GRM1555C1H102JA01D
C2142, C2143: 100n 50V selector local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2146: 100u 35V selected-PD hold-up; CP_Elec_6.3x7.7; MPN EEHZK1V101XP
C2403: 1u; C_0805_2012Metric; MPN GRM21BR71H105KA12L
C2413: 4.7n C0G PP5V slew; C_0603_1608Metric; MPN GRM1885C1H472JA01D
C2630: 100n 50V inverter bypass; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2682: 100n 50V qualifier bypass; C_0603_1608Metric; MPN GRM188R71H104KA93D
D2080: B340A eFuse output negative-transient clamp; D_SMA; MPN B340A-13-F
D2100, D2101, D2102, D2103, D2104, D2105, D2106, D2107: TPD1E0B04DPLR 0.13pF USB3 ESD; D_0201_0603Metric; MPN TPD1E0B04DPLR
F195: 5A AUX source fuse: Bel 0678H5000-02; Bel_0678H_3912; MPN 0678H5000-02
H10, H11, H12, H16: M2.5 isolated mainboard mounting hole; MountingHole_2.7mm_M2.5
J21: USB-C dual-role data/PD port J21; USB_C_Receptacle_Molex_105450-0101; MPN 105450-0101
J190: AUX/SOLAR protected screw terminal 6-22V nominal; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; MPN 1715022
Q15, Q16: SiSS4409DN 40V reverse-blocking PMOS; Vishay_PowerPAK_1212-8_Single; MPN SiSS4409DN-T1-GE3
Q2001: 2N7002K DFP USB2 enable inverter; SOT-23; MPN 2N7002KT1G
Q2630: BSS138 switched discharge; SOT-23; MPN BSS138LT1G
R2000: 10k shared CC/USB2 protector FLT pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2001: 2.2k EEPROM SDA pull-up; R_0603_1608Metric; MPN RC0603FR-072K2L
R2002: 2.2k EEPROM SCL pull-up; R_0603_1608Metric; MPN RC0603FR-072K2L
R2003: 4.7k TCPC SDA pull-up; R_0603_1608Metric; MPN RC0603FR-074K7L
R2004: 4.7k TCPC SCL pull-up; R_0603_1608Metric; MPN RC0603FR-074K7L
R2005: 10k TCPC IRQ pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2006: 10k mux FLIP pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2007: 10k mux EN pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2008: 1k TUSB1142 MODE=0 strap; R_0603_1608Metric; MPN RC0603FR-071KL
R2009: 1k TUSB1142 VIO=3V3 strap; R_0603_1608Metric; MPN RC0603FR-071KL
R2010: 1k TUSB1142 EQCFG=0 strap; R_0603_1608Metric; MPN RC0603FR-071KL
R2011: 1k TUSB1142 SSEQ1=0 strap; R_0603_1608Metric; MPN RC0603FR-071KL
R2012: 10k TUSB1142 SLP_S0# pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2013: 100k mux FLIP input default-low; R_0603_1608Metric; MPN RC0603FR-07100KL
R2014: 100k data-attach input default-low; R_0603_1608Metric; MPN RC0603FR-07100KL
R2015: 10k I2Cc IRQ inactive pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2016: 100k USB2 switch default-disable pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R2017: 0R protector FLT wired-OR link; R_0603_1608Metric; MPN RC0603FR-070RL
R2018: 100k DFP-role input default-low; R_0603_1608Metric; MPN RC0603FR-07100KL
R2080: 1k 1W switched input discharge; R_2512_6332Metric; MPN RC2512FR-071KL
R2081: 100k discharge gate default-low; R_0603_1608Metric; MPN RC0603FR-07100KL
R2082: 1k IMON load; R_0603_1608Metric; MPN RC0603FR-071KL
R2083: 267R 0.1% sink breaker; 5.58A nominal; R_0603_1608Metric; MPN RT0603BRD07267RL
R2084: 47k sink enable default-off; R_0603_1608Metric; MPN RC0603FR-0747KL
R2085: 10k sink enable series; R_0603_1608Metric; MPN RC0603FR-0710KL
R2086: 150k sink PG pull-up; valid with input off; R_0603_1608Metric; MPN RC0603FR-07150KL
R2140: 76.8k 0.02% 5ppm 5..20V UV top; R_0603_1608Metric; MPN TNPU060376K8HZEN00
R2141: 21.5k 0.02% 5ppm 5..20V window middle; R_0603_1608Metric; MPN TNPU060321K5HZEN00
R2142: 4.53k 0.02% 5ppm 5..20V OV bottom; R_0603_1608Metric; MPN TNPU06034K53HZEN00
R2146: 10k PD1 VALID pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2403: 100k; R_0603_1608Metric; MPN RC0603FR-07100KL
R2413: 10k; R_0603_1608Metric; MPN RC0603FR-0710KL
U14: LTC4418IUF#PBF dual-input PD selector (V1 = J21); ADI_UF20_QFN20_4x4_P0.5_EP2.45; MPN LTC4418IUF#PBF
U41: TPS25751AD USB-PD DRP controller; Texas_REF0038A_WQFN-38-2EP_6x4mm_P0.4; MPN TPS25751ADREFR
U720: TPS259827ONRGER PD1 sink breaker; Texas_RGE0024M_QFN24_4x4_2EP; MPN TPS259827ONRGER
U2000: TUSB1142 USB 3.2 Gen 2 orientation redriver; Texas_RNQ0040A_WQFN-40-1EP_6x4mm_P0.4mm_EP4.7x2.7mm_Thermal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; MPN TUSB1142IRNQR
U2001: TPD4S201 CC and USB2 short-to-VBUS protector; Texas_RUK0020B_WQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm_Thermal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; MPN TPD4S201RUKR
U2002: CAT24C256 32KB private TPS25751A EEPROM; SOIC-8_3.9x4.9mm_P1.27mm; MPN CAT24C256WI-GT3
U2003: TS3USB30E DFP-qualified USB2 disconnect; TSSOP-10_3x3mm_P0.5mm; MPN TS3USB30EDGSR
U2004: SN74LVC2G07 partial-power-down mux controls; SOT-363_SC-70-6; MPN SN74LVC2G07DCKR
U2005: TVS2200 22V USB VBUS surge clamp; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TVS2200DRVR
U2006: SN74LVC1G08 DFP and attached qualifier; SOT-23-5; MPN SN74LVC1G08DBVR
U2403: TPS22992SRXNR J21 PP5V gate; Texas_RXN0008A_WQFN-HR-8_1.25x1.25mm; MPN TPS22992SRXNR
U2630: SN74LVC1G04DBVR discharge control; SOT-23-5; MPN SN74LVC1G04DBVR

Connections:
/AUX_DC_RAW: F195.2; also elsewhere on the board
/MCU_3V3: C2022.1, C2630.1, R2000.1, R2003.1, R2004.1, R2005.1, R2086.1, R2146.1, U41.38 (VIN_3V3), U2630.5 (VCC); also elsewhere on the board
/PD1 Dual-Role/AUX_DC_TERM: F195.1, J190.1
/PD1 Dual-Role/J21_PP5V_CT: C2413.1, U2403.7 (CT)
/PD1 Dual-Role/PD1_CC1_CONN: J21.A5 (CC1), U2001.4 (C_CC1), U2001.7 (RPD_G1)
/PD1 Dual-Role/PD1_CC1_SYS: C2023.1, U41.28 (CC1), U2001.12 (CC1)
/PD1 Dual-Role/PD1_CC2_CONN: J21.B5 (CC2), U2001.5 (C_CC2), U2001.6 (RPD_G2)
/PD1 Dual-Role/PD1_CC2_SYS: C2024.1, U41.29 (CC2), U2001.11 (CC2)
/PD1 Dual-Role/PD1_CC_ESD_VBIAS: C2000.1, U2001.3 (VBIAS)
/PD1 Dual-Role/PD1_CC_FAULT_LOCAL_N: R2017.1, U2001.9 (FLT)
/PD1 Dual-Role/PD1_CONN_DN: J21.A7 (D-), J21.B7 (D-), U2001.2 (C_SBU2)
/PD1 Dual-Role/PD1_CONN_DP: J21.A6 (D+), J21.B6 (D+), U2001.1 (C_SBU1)
/PD1 Dual-Role/PD1_CTX1_RAW_N: C2012.1, U2000.34 (CTX1n)
/PD1 Dual-Role/PD1_CTX1_RAW_P: C2011.1, U2000.33 (CTX1p)
/PD1 Dual-Role/PD1_CTX2_RAW_N: C2014.1, U2000.39 (CTX2n)
/PD1 Dual-Role/PD1_CTX2_RAW_P: C2013.1, U2000.40 (CTX2p)
/PD1 Dual-Role/PD1_DISCHARGE: Q2630.1 (G), R2081.1, U2630.4
/PD1 Dual-Role/PD1_DISCHARGE_DRAIN: Q2630.3 (D), R2080.2
/PD1 Dual-Role/PD1_DRAIN_THERMAL: U41.15 (DRAIN), U41.30 (DRAIN), U41.40 (DRAIN)
/PD1 Dual-Role/PD1_EEPROM_IRQ_N: R2015.2, U41.18 (I2Cc_IRQ)
/PD1 Dual-Role/PD1_EEPROM_SCL: R2002.2, U41.17 (I2Cc_SCL), U2002.6 (SCL)
/PD1 Dual-Role/PD1_EEPROM_SDA: R2001.2, U41.16 (I2Cc_SDA), U2002.5 (SDA)
/PD1 Dual-Role/PD1_EFUSE_DVDT: C2082.1, U720.15 (dVdt)
/PD1 Dual-Role/PD1_EFUSE_ILIM: R2083.1, U720.8 (ILIM)
/PD1 Dual-Role/PD1_EFUSE_IMON: R2082.1, U720.9 (IMON)
/PD1 Dual-Role/PD1_EFUSE_SHDN: R2084.1, R2085.2, U720.6 (EN/UVLO)
/PD1 Dual-Role/PD1_GPIO_ATTACH: R2014.1, U41.36 (GPIO7), U2006.2
/PD1 Dual-Role/PD1_GPIO_DFP: R2018.1, U41.26 (GPIO4/USB_P), U2006.1
/PD1 Dual-Role/PD1_GPIO_FLIP: R2013.1, U41.37 (GPIO6), U2004.1
/PD1 Dual-Role/PD1_HOST_ATTACHED: U2004.3, U2006.4
/PD1 Dual-Role/PD1_HOST_SWITCHED_DN: U2001.14 (SBU2), U2003.6 (D-)
/PD1 Dual-Role/PD1_HOST_SWITCHED_DP: U2001.15 (SBU1), U2003.4 (D+)
/PD1 Dual-Role/PD1_LDO1V5: C2021.1, C2692.1, U41.4 (LDO_1V5)
/PD1 Dual-Role/PD1_LDO3V3: C2001.1, C2002.1, C2020.1, R2001.1, R2002.1, R2015.1, U41.1 (LDO_3V3), U41.2 (ADCIN1), U2001.10 (VPWR), U2002.8 (VCC)
/PD1 Dual-Role/PD1_MUX_EN: Q2001.1 (G), R2007.2, U2000.26 (EN), U2004.4
/PD1 Dual-Role/PD1_MUX_EQCFG: R2010.1, U2000.3 (EQCFG)
/PD1 Dual-Role/PD1_MUX_FLIP: R2006.2, U2000.21 (FLIP/SCL), U2004.6
/PD1 Dual-Role/PD1_MUX_MODE: R2008.1, U2000.17 (MODE)
/PD1 Dual-Role/PD1_MUX_SLEEP_N: R2012.2, U2000.4 (SLP_S0#)
/PD1 Dual-Role/PD1_MUX_SSEQ1: R2011.1, U2000.2 (SSEQ1/A1)
/PD1 Dual-Role/PD1_MUX_VIO: R2009.1, U2000.14 (VIO_SEL)
/PD1 Dual-Role/PD1_PP5V_GATED: C2025.1, C2026.1, C2027.1, R2413.1, U41.34 (PP5V_(34-35)), U2403.5 (QOD), U2403.6 (VOUT)
/PD1 Dual-Role/PD1_PPHV: C2028.1, C2029.1, C2080.1, U41.20 (PPHV_(20-22)), U720.1 (IN), U720.2 (IN), U720.3 (IN), U720.16 (IN), U720.25 (IN)
/PD1 Dual-Role/PD1_RX1_N: D2105.1 (IO), J21.B10 (RX1-), U2000.31 (CRX1n)
/PD1 Dual-Role/PD1_RX1_P: D2104.1 (IO), J21.B11 (RX1+), U2000.30 (CRX1p)
/PD1 Dual-Role/PD1_RX2_N: D2107.1 (IO), J21.A10 (RX2-), U2000.36 (CRX2n)
/PD1 Dual-Role/PD1_RX2_P: D2106.1 (IO), J21.A11 (RX2+), U2000.37 (CRX2p)
/PD1 Dual-Role/PD1_SEL_FET_COMMON: C2143.1, Q15.2 (S), Q15.3 (S), Q15.4 (S), Q16.2 (S), Q16.3 (S), Q16.4 (S), U14.14 (VS1)
/PD1 Dual-Role/PD1_SEL_GATE: Q15.1 (G), Q16.1 (G), U14.13 (G1)
/PD1 Dual-Role/PD1_SEL_OV: R2141.2, R2142.1, U14.3 (OV1)
/PD1 Dual-Role/PD1_SEL_UV: R2140.2, R2141.1, U14.2 (UV1)
/PD1 Dual-Role/PD1_SSRX_RAW_N: C2010.1, U2000.18 (SSRXn)
/PD1 Dual-Role/PD1_SSRX_RAW_P: C2009.1, U2000.19 (SSRXp)
/PD1 Dual-Role/PD1_TX1_N: C2012.2, D2101.1 (IO), J21.A3 (TX1-)
/PD1 Dual-Role/PD1_TX1_P: C2011.2, D2100.1 (IO), J21.A2 (TX1+)
/PD1 Dual-Role/PD1_TX2_N: C2014.2, D2103.1 (IO), J21.B3 (TX2-)
/PD1 Dual-Role/PD1_TX2_P: C2013.2, D2102.1 (IO), J21.B2 (TX2+)
/PD1 Dual-Role/PD1_USB2_OE_N: Q2001.3 (D), R2016.2, U2003.9 (~OE)
/PD1 Dual-Role/PD1_VBUS_GATED: C2081.1, C2142.1, D2080.1 (K), Q15.5 (D(5-8)), R2080.1, R2140.1, U14.17 (V1), U720.17 (OUT), U720.18 (OUT), U720.19 (OUT), U720.20 (OUT), U720.21 (OUT), U720.22 (OUT), U720.23 (OUT), U720.24 (OUT)
/PD1 Dual-Role/PD_SEL_INTVCC: C2140.1, U14.10 (INTVCC), U14.18 (EN), U14.19 (~SHDN)
/PD1 Dual-Role/PD_SEL_TMR: C2141.1, U14.1 (TMR)
/PD1_EFUSE_PG: R2086.2, U720.13 (PG); also elsewhere on the board
/PD1_I2C_SCL: R2004.2, U41.9 (I2Ct_SCL); also elsewhere on the board
/PD1_I2C_SDA: R2003.2, U41.8 (I2Ct_SDA); also elsewhere on the board
/PD1_PATH_EN: R2085.1, U2630.2; also elsewhere on the board
/PD1_SOURCE_PG: R2413.2, U2403.3 (PG); also elsewhere on the board
/PD1_TCPC_IRQ_N: R2005.2, U41.10 (I2Ct_IRQ); also elsewhere on the board
/PD1_VALID_N: R2146.2, U14.6 (~VALID1); also elsewhere on the board
/PD1_VBUS_RAW: C2015.1, C2016.1, C2017.1, C2018.1, C2019.1, J21.A4 (VBUS), J21.A9 (VBUS), J21.B4 (VBUS), J21.B9 (VBUS), U41.23 (VBUS_IN_(23-25)), U41.32 (VBUS_(32-33)), U2005.4 (IN), U2005.5 (IN), U2005.6 (IN); also elsewhere on the board
/PD_PROTECT_FAULT_N: R2000.2, R2017.2; also elsewhere on the board
/SYS_3V3: C2003.1, C2004.1, C2005.1, C2006.1, C2007.1, C2008.1, C2030.1, C2682.1, R2006.1, R2007.1, R2012.1, R2016.1, U2000.1 (VCC), U2000.6 (VCC), U2000.20 (VCC), U2000.28 (VCC), U2003.10 (VCC), U2004.5 (VCC), U2006.5 (VCC); also elsewhere on the board
/USBC1_DN: U2003.8 (D1-); also elsewhere on the board
/USBC1_DP: U2003.2 (D1+); also elsewhere on the board
/USBC1_SSRX_N: C2010.2; also elsewhere on the board
/USBC1_SSRX_P: C2009.2; also elsewhere on the board
/USBC1_SSTX_N: U2000.15 (SSTXn); also elsewhere on the board
/USBC1_SSTX_P: U2000.16 (SSTXp); also elsewhere on the board
/USB_J21_PERMIT: R2403.1, U2403.8 (ON); also elsewhere on the board
/USB_PD_SELECTED: C2146.1, Q16.5 (D(5-8)), U14.15 (VOUT); also elsewhere on the board
/USB_PORT_5V: C2403.1, U2403.1 (VBIAS), U2403.2 (VIN); also elsewhere on the board
GND: C2000.2, C2001.2, C2002.2, C2003.2, C2004.2, C2005.2, C2006.2, C2007.2, C2008.2, C2015.2, C2016.2, C2017.2, C2018.2, C2019.2, C2020.2, C2021.2, C2022.2, C2023.2, C2024.2, C2025.2, C2026.2, C2027.2, C2028.2, C2029.2, C2030.2, C2080.2, C2081.2, C2082.2, C2140.2, C2141.2, C2142.2, C2143.2, C2146.2, C2403.2, C2413.2, C2630.2, C2682.2, C2692.2, D2080.2 (A), D2100.2 (IO), D2101.2 (IO), D2102.2 (IO), D2103.2 (IO), D2104.2 (IO), D2105.2 (IO), D2106.2 (IO), D2107.2 (IO), J21.A1 (GND), J21.A12 (GND), J21.B1 (GND), J21.B12 (GND), J21.SH (SHIELD), J190.2, Q2001.2 (S), Q2630.2 (S), R2008.2, R2009.2, R2010.2, R2011.2, R2013.2, R2014.2, R2018.2, R2081.2, R2082.2, R2083.2, R2084.2, R2142.2, R2403.2, U14.4 (UV2), U14.5 (OV2), U14.8 (GND), U14.12 (VS2), U14.16 (V2), U14.20 (HYS), U14.21 (EP/GND), U41.3 (ADCIN2), U41.5 (GPIO0/LD1), U41.6 (GPIO1), U41.7 (GPIO2/LD2), U41.11 (GND), U41.12 (GND), U41.13 (GPIO11), U41.14 (GND), U41.19 (GPIO3), U41.27 (GPIO5/USB_N), U41.31 (GND), U41.39 (GND), U720.4 (GND), U720.5 (GND), U720.10 (RETRY_DLY), U720.11 (NRETRY), U720.12 (LDSTRT), U720.14 (GND), U720.26 (GND), U2000.22 (AEQENZ/SDA), U2000.27 (TEST1), U2000.41 (GND), U2001.8 (GND), U2001.13 (GND), U2001.18 (GND), U2001.21 (GND), U2002.1 (A0), U2002.2 (A1), U2002.3 (A2), U2002.4 (GND), U2002.7 (WP), U2003.1 (S), U2003.5 (GND), U2004.2 (GND), U2005.1 (GND), U2005.2 (GND), U2005.3 (GND), U2005.7 (GND), U2006.3 (GND), U2403.4 (GND), U2630.3 (GND); also elsewhere on the board

Notes on the sheet:
== Left I/O: PD1 dual-role port (J21) + AUX input (J190) ==
== J21: USB 3.2 Gen 2 data plus USB-PD charging, side port 1 ==
J21: hardware accepts 15V/20V PD; use a verified 3A contract and 2.50A IINDPM bootstrap command. Actual current/headroom and EEPROM/profile qualification remain required.
GPIO4 AND GPIO7 qualifies both host USB2 and SuperSpeed. They remain disconnected through reset, detach, and sink-only operation.
== U14: two-input qualified PD selector; J21 has priority over J11 ==
The EC selects one qualified sink path, waits for power good and voltage validation, then applies the verified charger input limit.
LTC4418 validates the 5..20V input window and blocks backfeed. The sink switch discharges its output when disabled.
Phase 5: J11 (PD2) charge power is selected on the CENTER board (U16); this board exports its own gated VBUS only.
Seven port permissions reserve VBUS, VCONN and branch losses before power is applied.

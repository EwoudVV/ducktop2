# Repository EwoudVV/ducktop2 (continued)

## KiCad design ducktop2.kicad_pcb (continued)

Schematic: 15_system_audio.kicad_sch

Parts:
C400: 100n AUDIO_5V high-frequency bypass; C_0603_1608Metric; MPN GRM188R71H104KA93D
C401: 10u AUDIO_5V local bulk; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C402: 1u TPS2052B input; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C403: 10u radio-codec host VBUS; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C404: 10u system-DAC VBUS; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C405: 100n VDDA33 pin 5; C_0603_1608Metric; MPN GRM188R71H104KA93D
C406: 100n VDDA33 pin 10; C_0603_1608Metric; MPN GRM188R71H104KA93D
C407: 100n VDDA33 pin 29; C_0603_1608Metric; MPN GRM188R71H104KA93D
C408: 100n VDDA33 pin 36; C_0603_1608Metric; MPN GRM188R71H104KA93D
C409: 100n VDD33 pin 15; C_0603_1608Metric; MPN GRM188R71H104KA93D
C410: 100n VDD33 pin 23; C_0603_1608Metric; MPN GRM188R71H104KA93D
C411: 1u shared hub 3V3 bulk; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C412: 100n CRFILT low-ESR; C_0603_1608Metric; MPN GRM188R71H104KA93D
C413: 100n PLLFILT low-ESR; C_0603_1608Metric; MPN GRM188R71H104KA93D
C414, C415: 18p C0G 5% hub crystal load; C_0603_1608Metric; MPN GRM1885C1H180JA01
C416: 100n reset supervisor local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C420, C421: 18p C0G 5% codec crystal load; C_0603_1608Metric; MPN GRM1885C1H180JA01
C422: 1u PCM2900 VBUS after 2.2R; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C423: 10u PCM2900 VCCCI; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C424: 1u PCM2900 VCCP1I less than 2u; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C425: 1u PCM2900 VCCP2I less than 2u; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C426: 1u PCM2900 VCCXI less than 2u; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C427: 1u PCM2900 VDDI less than 2u; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C428: 100n AND-gate local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C429: 10u PCM2900 VCOM; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C430: 47n L DAC out-of-band shunt; C_0603_1608Metric; MPN GRM188R71H473KA01
C431: 47n R DAC out-of-band shunt; C_0603_1608Metric; MPN GRM188R71H473KA01
C432: 1u L positive-input AC coupling; C_0805_2012Metric; MPN GRM21BR71H105KA01
C433: 1u R positive-input AC coupling; C_0805_2012Metric; MPN GRM21BR71H105KA01
C434: 1u L negative-input AC reference; C_0805_2012Metric; MPN GRM21BR71H105KA01
C435: 1u R negative-input AC reference; C_0805_2012Metric; MPN GRM21BR71H105KA01
C440: 100n amplifier supply at AVDD/PVDD; C_0603_1608Metric; MPN GRM188R71H104KA93D
C441: 10u amplifier local bulk; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C442, C443, C444, C445: 1n speaker EMI shunt per TI Figure 36; C_0402_1005Metric; MPN GRM155R71H102KA01
C446, C447: 100u 10V polymer downstream VBUS bulk; CP_EIA-3528-21_Kemet-B; MPN T520B107M010ATE070
C448: 1u LP5907 input; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C449: 1u LP5907 output; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C450: 100n microphone VDD at pin 3; C_0603_1608Metric; MPN GRM188R71H104KA93D
C452: 100n TLV9061 local bypass; C_0603_1608Metric; MPN GRM188R71H104KA93D
C453: 1.2n C0G feedback low-pass; C_0603_1608Metric; MPN GRM1885C1H122JA01
C454: 4.7u microphone gain-leg AC coupling; C_1206_3216Metric; MPN GRM31CR61C475KA01
C455: 4.7u microphone to PCM2900 VINL per TI analog fro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; C_1206_3216Metric; MPN GRM31CR61C475KA01
C456: 4.7u microphone to PCM2900 VINR per TI analog fro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; C_1206_3216Metric; MPN GRM31CR61C475KA01
C457: 0.47u L input coupling to LEFTINM; C_0805_2012Metric; MPN GRM21BR71H474KA01
C458: 0.47u L INP AC-ground reference; C_0805_2012Metric; MPN GRM21BR71H474KA01
C459: 0.47u R input coupling to RIGHTINM; C_0805_2012Metric; MPN GRM21BR71H474KA01
C460: 0.47u R INP AC-ground reference; C_0805_2012Metric; MPN GRM21BR71H474KA01
C461: 1u charge-pump flying CPP-CPN; C_0805_2012Metric; MPN GRM21BR71H105KA01
C462: 1u CPVSS negative-rail decoupling; C_0805_2012Metric; MPN GRM21BR71H105KA01
C463: 1u VDD pin 12 analog bypass; C_0805_2012Metric; MPN GRM21BR71H105KA01
C464: 1u VDD pin 20 charge-pump supply bypass; C_0805_2012Metric; MPN GRM21BR71H105KA01
C465: 100n VDD high-frequency bypass; C_0603_1608Metric; MPN GRM188R71H104KA93D
F400: 1.5A hold resettable PTC; Littelfuse 1812L150/16DR; Fuse_1812_4532Metric; MPN 1812L150/16DR
J420: Left 8-ohm BTL speaker; pin 1 +, pin 2 -; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal; MPN SM02B-GHS-TB
J421: Right 8-ohm BTL speaker; pin 1 +, pin 2 -; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal; MPN SM02B-GHS-TB
J422: CUI SJ1-3535NG rear 3.5mm stereo headphone jack; Jack_3.5mm_CUI_SJ1-3535NG_Horizontal; MPN SJ1-3535NG
L420, L421, L422, L423: MPZ1608S221A 220R@100MHz speaker EMI bead; L_0603_1608Metric; MPN MPZ1608S221A
LED430: green microphone-active indicator; LED_0603_1608Metric; MPN APT1608SGC
MK430: IM68A130V01 bottom-port analog MEMS microphone; Infineon_IM68A130V01; MPN IM68A130V01XTMA1
R400: 12.0k 1% USB transceiver RBIAS; R_0603_1608Metric; Tolerance 1%; MPN RC0603FR-0712K0L
R401: 10k reset open-drain pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R402: 100k NON_REM1 strap low; R_0603_1608Metric; MPN RC0603FR-07100KL
R403: 10k NON_REM0 strap high; R_0603_1608Metric; MPN RC0603FR-0710KL
R404: 100k CFG_SEL0 strap low; R_0603_1608Metric; MPN RC0603FR-07100KL
R405: 100k CFG_SEL1 strap low; R_0603_1608Metric; MPN RC0603FR-07100KL
R408: 10k port 1 OC_N noise-margin pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R409: 10k port 2 OC_N noise-margin pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R410: 22R system DAC USB D- series; R_0603_1608Metric; MPN RC0603FR-0722RL
R411: 22R system DAC USB D+ series; R_0603_1608Metric; MPN RC0603FR-0722RL
R412: 1.5k USB D+ pull-up per TI Figure 38; R_0603_1608Metric; MPN RC0603FR-071K5L
R413: 2.2R PCM2900C VBUS filter; R_0603_1608Metric; MPN RC0603FR-072R2L
R414: 1M PCM2900 crystal feedback; R_0603_1608Metric; MPN RC0603FR-071ML
R415: 100k EC enable fail-safe pull-down; R_0603_1608Metric; MPN RC0603FR-07100KL
R416: 100k SSPND fail-safe pull-down; R_0603_1608Metric; MPN RC0603FR-07100KL
R417: 0R physical internal-host VBUS-valid link; R_0603_1608Metric; MPN RC0603JR-070RL
R420: 100R L DAC out-of-band filter; R_0603_1608Metric; MPN RC0603FR-07100RL
R421: 100R R DAC out-of-band filter; R_0603_1608Metric; MPN RC0603FR-07100RL
R432: 4.99k 1% microphone feedback; R_0603_1608Metric; MPN RC0603FR-074K99L
R433: 1.00k 1% microphone gain leg; R_0603_1608Metric; MPN RC0603FR-071KL
R434: 100k microphone enable fail-off pull-down; R_0603_1608Metric; MPN RC0603FR-07100KL
R435: 2.2k microphone-active indicator; R_0603_1608Metric; MPN RC0603FR-072K2L
U400: USB2512B-AEZG-TR two-port HS multi-TT hub; QFN-36-1EP_6x6mm_P0.5mm_EP3.7x3.7mm_ThermalVias; MPN USB2512B-AEZG-TR
U401: TLV803EA29RDBZR 2.93V reset supervisor; SOT-23-3; MPN TLV803EA29RDBZR
U402: TPS2052BDR dual 500mA USB power switch; SOIC-8_3.9x4.9mm_P1.27mm; MPN TPS2052BDR
U410: PCM2900CDBR USB Audio Class stereo codec; SSOP-28_5.3x10.2mm_P0.65mm; MPN PCM2900CDBR
U420: TPA2012D2RTJR stereo BTL class-D amplifier; WQFN-20-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_ThermalVias; MPN TPA2012D2RTJR
U421: SN74LVC1G08DBVR SSPND AND EC audio enable; SOT-23-5; MPN SN74LVC1G08DBVR
U425: TPA6130A2RTJR DirectPath stereo headphone amp; WQFN-20-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_ThermalVias; MPN TPA6130A2RTJR
U430: LP5907MFX-2.8/NOPB low-noise microphone LDO; SOT-23-5; MPN LP5907MFX-2.8/NOPB
U431: TLV9061IDBVR microphone preamplifier; SOT-23-5; MPN TLV9061IDBVR
Y400: ABM8-24.000MHZ-10-1-U-T 24MHz 10pF CL; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN ABM8-24.000MHZ-10-1-U-T
Y410: ABM8G-106-12.000MHZ-T 12MHz 10pF CL; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN ABM8G-106-12.000MHZ-T

Connections:
/AUDIO_AMP_EC_EN: R415.1, U421.2; also elsewhere on the board
/AUDIO_MIC_EN: R434.1, U430.3 (EN); also elsewhere on the board
/AUDIO_USB_DM: U400.30 (USBDM_UP); also elsewhere on the board
/AUDIO_USB_DP: U400.31 (USBDP_UP); also elsewhere on the board
/HP_DETECT: J422.RN; also elsewhere on the board
/I2C_SCL: U425.8 (SCL); also elsewhere on the board
/I2C_SDA: U425.7 (SDA); also elsewhere on the board
/INTERNAL_USB_VBUS_VALID: R417.1; also elsewhere on the board
/MU_HOST_ACTIVE: U425.6 (~SD); also elsewhere on the board
/RADIO_CODEC_USB_DM_HOST: U400.3 (USBDM_DN2/PRT_DIS_M2); also elsewhere on the board
/RADIO_CODEC_USB_DP_HOST: U400.4 (USBDP_DN2/PRT_DIS_P2); also elsewhere on the board
/RADIO_CODEC_USB_VBUS_HOST: C403.1, C446.1, U402.6 (OUT2); also elsewhere on the board
/SYS_3V3: C405.1, C406.1, C407.1, C408.1, C409.1, C410.1, C411.1, C416.1, C428.1, C448.1, C452.1, R401.1, R403.2, R408.1, R409.1, U400.5 (VDDA33), U400.10 (VDDA33), U400.15 (VDD33), U400.23 (VDD33), U400.29 (VDDA33), U400.36 (VDDA33), U401.3 (VDD), U421.5 (VCC), U430.1 (IN), U431.5 (V+); also elsewhere on the board
/SYS_5V: F400.1; also elsewhere on the board
/System Audio/AMP_ENABLE: U420.7 (SDL), U420.8 (SDR), U421.4
/System Audio/AMP_IN_LN: C434.1, U420.19 (INL-)
/System Audio/AMP_IN_LP: C432.2, U420.20 (INL+)
/System Audio/AMP_IN_RN: C435.1, U420.17 (INR-)
/System Audio/AMP_IN_RP: C433.2, U420.16 (INR+)
/System Audio/AMP_OUT_LN: L421.1, U420.5 (OUTL-)
/System Audio/AMP_OUT_LP: L420.1, U420.2 (OUTL+)
/System Audio/AMP_OUT_RN: L423.1, U420.11 (OUTR-)
/System Audio/AMP_OUT_RP: L422.1, U420.14 (OUTR+)
/System Audio/AUDIO_5V: C400.1, C401.1, C402.1, C440.1, C441.1, C463.1, C464.1, C465.1, F400.2, U402.2 (IN), U420.3 (PVDD), U420.9 (AVDD), U420.13 (PVDD), U420.15 (G0), U425.12 (VDD), U425.20 (VDD)
/System Audio/CODEC_USB_DM: R410.2, U410.2 (D-)
/System Audio/CODEC_USB_DP: R411.2, R412.2, U410.1 (D+)
/System Audio/CODEC_VBUS: C422.1, R413.2, U410.3 (VBUS)
/System Audio/CODEC_VCCCI: C423.1, U410.10 (VCCCI)
/System Audio/CODEC_VCCP1I: C424.1, U410.17 (VCCP1I)
/System Audio/CODEC_VCCP2I: C425.1, U410.19 (VCCP2I)
/System Audio/CODEC_VCCXI: C426.1, U410.23 (VCCXI)
/System Audio/CODEC_VCOM: C429.1, U410.14 (VCOM)
/System Audio/CODEC_VDDI: C427.1, R412.1, U410.8 (SEL0), U410.9 (SEL1), U410.27 (VDDI)
/System Audio/CODEC_XTI: C420.1, R414.1, U410.21 (XTI), Y410.1
/System Audio/CODEC_XTO: C421.1, R414.2, U410.20 (XTO), Y410.3
/System Audio/CPN: C461.2, U425.17 (CPN)
/System Audio/CPP: C461.1, U425.18 (CPP)
/System Audio/CPVSS: C462.1, U425.15 (CPVSS), U425.16 (CPVSS)
/System Audio/DAC_L_LPF: C430.1, C432.1, R420.2
/System Audio/DAC_R_LPF: C431.1, C433.1, R421.2
/System Audio/DAC_SSPND: R416.1, U410.28 (~SSPND), U421.1
/System Audio/DAC_VOUT_L: C457.1, R420.1, U410.16 (VOUTL)
/System Audio/DAC_VOUT_R: C459.1, R421.1, U410.15 (VOUTR)
/System Audio/HP_INM_L: C457.2, U425.1 (LEFTINM)
/System Audio/HP_INM_R: C459.2, U425.5 (RIGHTINM)
/System Audio/HP_INP_L: C458.1, U425.2 (LEFTINP)
/System Audio/HP_INP_R: C460.1, U425.4 (RIGHTINP)
/System Audio/HP_OUT_L: J422.T, U425.14 (HPLEFT)
/System Audio/HP_OUT_R: J422.R, U425.11 (HPRIGHT)
/System Audio/HUB_CFG_SEL0: R404.1, U400.24 (SCL/SMBCLK/CFG_SEL0)
/System Audio/HUB_CFG_SEL1: R405.1, U400.25 (HS_IND/CFG_SEL1)
/System Audio/HUB_CRFILT: C412.1, U400.14 (CRFILT)
/System Audio/HUB_NON_REM0: R403.1, U400.28 (SUSP_IND/LOCAL_PWR/NON_REM0)
/System Audio/HUB_NON_REM1: R402.1, U400.22 (SDA/SMBDATA/NON_REM1)
/System Audio/HUB_PLLFILT: C413.1, U400.34 (PLLFILT)
/System Audio/HUB_PORT1_EN: U400.12 (PRTPWR1/BC_EN1), U402.3 (EN1)
/System Audio/HUB_PORT1_OC_N: R408.2, U400.13 (OCS_N1), U402.8 (OC1)
/System Audio/HUB_PORT2_EN: U400.16 (PRTPWR2/BC_EN2), U402.4 (EN2)
/System Audio/HUB_PORT2_OC_N: R409.2, U400.17 (OCS_N2), U402.5 (OC2)
/System Audio/HUB_RBIAS: R400.1, U400.35 (RBIAS)
/System Audio/HUB_RESET_N: R401.2, U400.26 (RESET_N), U401.1 (RESETz)
/System Audio/HUB_VBUS_DET: R417.2, U400.27 (VBUS_DET)
/System Audio/HUB_XI: C414.1, U400.33 (XTALIN/CLKIN), Y400.1
/System Audio/HUB_XO: C415.1, U400.32 (XTALOUT), Y400.3
/System Audio/MIC_2V8: C449.1, C450.1, MK430.3 (VDD), R435.1, U430.5 (OUT)
/System Audio/MIC_ADC_L: C455.2, U410.12 (VINL)
/System Audio/MIC_ADC_R: C456.2, U410.13 (VINR)
/System Audio/MIC_FB: C453.2, R432.2, R433.1, U431.4 (-)
/System Audio/MIC_HP_NODE: C454.1, R433.2
/System Audio/MIC_LED_A: LED430.2 (A), R435.2
/System Audio/MIC_PREAMP: C453.1, C455.1, C456.1, R432.1, U431.1
/System Audio/MIC_RAW: MK430.1 (OUT), U431.3 (+)
/System Audio/SPK_L_N: C443.1, J420.2, L421.2
/System Audio/SPK_L_P: C442.1, J420.1, L420.2
/System Audio/SPK_R_N: C445.1, J421.2, L423.2
/System Audio/SPK_R_P: C444.1, J421.1, L422.2
/System Audio/SYSTEM_DAC_USB_DM: R410.1, U400.1 (USBDM_DN1/PRT_DIS_M1)
/System Audio/SYSTEM_DAC_USB_DP: R411.1, U400.2 (USBDP_DN1/PRT_DIS_P1)
/System Audio/SYSTEM_DAC_USB_VBUS: C404.1, C447.1, R413.1, U402.7 (OUT1)
GND: C400.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, C420.2, C421.2, C422.2, C423.2, C424.2, C425.2, C426.2, C427.2, C428.2, C429.2, C430.2, C431.2, C434.2, C435.2, C440.2, C441.2, C442.2, C443.2, C444.2, C445.2, C446.2, C447.2, C448.2, C449.2, C450.2, C452.2, C454.2, C458.2, C460.2, C462.2, C463.2, C464.2, C465.2, J422.S, LED430.1 (K), MK430.2 (GND), MK430.4 (GND), R400.2, R402.2, R404.2, R405.2, R415.2, R416.2, R434.2, U400.37 (VSS_EP), U401.2 (GND), U402.1 (GND), U410.4 (DGNDU), U410.11 (AGNDC), U410.18 (AGNDP), U410.22 (AGNDX), U410.24 (TEST0), U410.26 (DGND), U420.1 (G1), U420.4 (PGND), U420.12 (PGND), U420.18 (AGND), U420.21 (THERMAL_PAD), U421.3 (GND), U425.3 (GND), U425.9 (GND), U425.10 (GND), U425.13 (GND), U425.19 (GND), U425.21 (PAD), U430.2 (GND), U431.2 (V-), Y400.2 (G), Y400.4 (G), Y410.2 (G), Y410.4 (G); also elsewhere on the board

Notes on the sheet:
== System audio: embedded two-port USB hub, playback/record codec, microphone, and stereo BTL amplifier ==
Mu USB2_P5 feeds a self-powered USB2512B multi-TT hub. Port 1 is the fixed PCM2900C system codec; port 2 is the optional radio daughterboard.
Port 1 is non-removable. Port 2 is removable and may be empty; TPS2052B provides individual protected VBUS outputs.
== Protected 5V audio branch and downstream USB power ==
== U400 USB2512B-AEZG-TR: self-powered, port 1 non-removable, port 2 removable ==
== U410 PCM2900CDBR system USB playback/record codec; TI Figure 38 bus-powered core ==
== Pop-safe amplifier enable: PCM2900 operational AND EC permission ==
== U420 TPA2012D2RTJR, 12dB gain, TI single-ended input and EMI networks ==
== Rear 3.5 mm headphone jack: TPA6130A2 DirectPath I2C headphone amp + plug-detect speaker mute ==
U425 taps the PCM2900C DAC_VOUT_L/R line outputs single-ended (0.47u coupling into LEFTINM/RIGHTINM, INP AC-grounded).
DirectPath capless outputs HPLEFT/HPRIGHT drive jack J422 T/R. RN (ring normalling) = HP_DETECT: unplugged shorts RN to R (amp 0V) -> low; plugged floats -> R782 100k pull-up (sheet 02) -> high.
EC reads HP_DETECT via U44 pin 6 over I2C; on plug-in it drives AUDIO_AMP_EC_EN low (U421 mutes speakers) and I2C-unmutes U425. /SD tied to MU_HOST_ACTIVE so U425 is in hardware shutdown (0.4uA) outside S0.
TPA6130A2 @0x60 (fixed). Power-on default = muted, outputs disabled (fail-safe OFF until EC firmware unmutes/enables over I2C). No G0/G1 hardware gain; 64-step I2C volume gives independent headphone level.
HEADPHONE LAYOUT: keep the jack, VDD bypass, and charge-pump caps away from the mic preamp (MK430) and class-D speaker outputs.
HEADPHONE STANDBY: /SD tied to MU_HOST_ACTIVE (S0-only) so U425 draws 0.4uA in S3; EC unmutes/enables over I2C only while host active.
== Built-in mono microphone: IM68A130 + low-noise 2.8V rail + low-noise preamp ==
U431 has DC gain 1 and audio-band gain 5.99V/V; the microphone's 1.3V output bias sets the quiescent output.
MIC PERFORMANCE: DC gain 1, audio-band gain 5.99V/V; shelving pole about 34Hz; feedback pole about 27kHz.
MIC TARGET: voice/conference capture up to about 105dBSPL. Expected analog clipping near 112-113dBSPL; this assembly is not a high-SPL recorder.
MIC LAYOUT: microphone and preamp are chip-down on the main PCB. Place at a front/top acoustic opening, far from blower, class-D outputs, RF PAs, and switching inductors.
MIC RELEASE GATE: verify footprint/stencil with assembler, seal the acoustic path, and test clipping/noise/echo with fans, radios, speakers, USB, and charging active.
RELEASE GATES:
1. Initial speakers: 8 ohm nominal and >=2W continuous each. Never join either BTL output to GND or use a shared speaker return.
2. A 4-ohm speaker is allowed only after amplifier/PCB thermal test, excursion test, current-budget check, and enforced host volume limiting.
3. Measure both crystal frequencies/startup margin, USB2 90-ohm routing, reset timing, and P5 enumeration on the production Mu BIOS.
4. Confirm the OS enumerates distinct PCM2900C system audio and PCM2902C radio audio devices across cold boot and suspend/resume.
5. Verify fail-off AUDIO_MIC_EN and the actual MIC_2V8-rail indicator; then run pop, echo, privacy, fan/charger noise, excursion, and RF-desense tests.
LAYOUT: place hub bypass/RBIAS/crystal at U400; codec crystal/decoupling at U410; mic chain at MK430; keep BTL pairs away from RF and mic input.
HUB_VBUS_DET follows the supervised carrier-generated physical INTERNAL_USB_VBUS. The audio hub cannot wake S3 and must re-enumerate after resume.

Schematic: 08_internal_services.kicad_sch

Parts:
C202: 100n thermal ADC filter; C_0603_1608Metric; MPN GRM188R71H104KA93D
C205: 10u 25V X7R fan local bulk; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C206: 100n 25V X7R fan local; C_0603_1608Metric; MPN GRM188R71E104KA01D
C207: 100n Mu thermal ADC filter; C_0603_1608Metric; MPN GRM188R71H104KA93D
C208: 100n EC USB switch local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C209: 3.9n fan FG filter; C_0402_1005Metric; MPN GRM1555C1H392JA01D
C280: 100n TPS2553 input bypass; C_0603_1608Metric; MPN GRM188R71E104KA01D
C283: 10u trackpad cable VBUS; C_1206_3216Metric; MPN GRM31CR71E106KA12L
F200: 750mA 16V fan polyfuse; Fuse_1206_3216Metric; MPN 1206L075/16WR
J50: DNP EC USB probe; PinHeader_1x04_P2.54mm_Vertical; not fitted
J52: Delta BFB04512HHA-CZ0T: GND, fused 12V, FG, PWM; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal; MPN SM04B-GHS-TB
J53: Lid/hall switch; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal; MPN SM02B-GHS-TB
J54: Skin/hinge NTC; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal; MPN SM02B-GHS-TB
J56: Mu heatsink/spreader NTC; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal; MPN SM02B-GHS-TB
J58: Field-soldered trackpad USB2 cable: GND/D-/D+/VBUS; USB2_Trackpad_Cable_SolderPads_1x04_P2.54mm
J73: Rear USB-C EC firmware programming port (UFP/DFU); USB_C_Receptacle_Molex_105450-0101; MPN 105450-0101
Q60: 2N7002 physical host-VBUS USB connect gate; SOT-23; MPN 2N7002KT1G
Q62: 2N7002 DFU-mode USB mux force-enable; SOT-23; MPN 2N7002KT1G
Q200: 2N7002KT1G fan PWM open-drain sink; SOT-23; MPN 2N7002KT1G
R200: 22R USB DP series; R_0603_1608Metric; MPN RC0603FR-0722RL
R201: 22R USB DM series; R_0603_1608Metric; MPN RC0603FR-0722RL
R202: 10k EC USB default-disconnect pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R203: 22R DFU USB DP series; R_0603_1608Metric; MPN RC0603FR-0722RL
R204: 22R DFU USB DM series; R_0603_1608Metric; MPN RC0603FR-0722RL
R205: 5.1k USB-C CC1 Rd (UFP); R_0603_1608Metric; MPN RC0603FR-075K1L
R206: 8.2k fan FG pull-up; R_0603_1608Metric; MPN RC0603FR-078K2L
R207: 100R fan PWM gate series; R_0603_1608Metric; MPN RC0603FR-07100RL
R208: 100k gate pull-down; fan defaults full speed; R_0603_1608Metric; MPN RC0603FR-07100KL
R209: 10k lid pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R210: 10k thermal divider pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R211: 5.1k USB-C CC2 Rd (UFP); R_0603_1608Metric; MPN RC0603FR-075K1L
R215: 10k Mu thermal pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R250: 22R trackpad DP series; R_0603_1608Metric; MPN RC0603FR-0722RL
R251: 22R trackpad DM series; R_0603_1608Metric; MPN RC0603FR-0722RL
R252: 43.2k 1% TPS2553 trackpad ILIM 0.61A nominal; R_0603_1608Metric; MPN RC0603FR-0743K2L
R256: 10k trackpad fault pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
U60: USBLC6-2P6 EC USB ESD; SOT-666; MPN USBLC6-2P6
U61: TS3USB30EDGSR EC USB host-state isolation; TSSOP-10_3x3mm_P0.5mm; MPN TS3USB30EDGSR
U62: TPD4E05U06 wired trackpad USB2 ESD; USON-10_2.5x1.0mm_P0.5mm; MPN TPD4E05U06DQAR
U63: USBLC6-2P6 EC DFU USB ESD; SOT-666; MPN USBLC6-2P6
U64: TPS2553DDBVR trackpad 0.61A branch switch; SOT-23-6; MPN TPS2553DDBVR

Connections:
/EC_DFU_SEL: Q62.1 (G), U61.1 (S); also elsewhere on the board
/EC_HOST_USB_DM: J50.2, U60.3 (I/O2), U60.4 (I/O2), U61.8 (D1-); also elsewhere on the board
/EC_HOST_USB_DP: J50.3, U60.1 (I/O1), U60.6 (I/O1), U61.2 (D1+); also elsewhere on the board
/FAN_PWM: R207.1; also elsewhere on the board
/FAN_TACH: C209.1, J52.3, R206.2; also elsewhere on the board
/INTERNAL_USB_VBUS_VALID: Q60.1 (G); also elsewhere on the board
/Internal Services/DFU_CONN_DM: J73.A7 (D-), J73.B7 (D-), R204.2, U63.3 (I/O2), U63.4 (I/O2)
/Internal Services/DFU_CONN_DP: J73.A6 (D+), J73.B6 (D+), R203.2, U63.1 (I/O1), U63.6 (I/O1)
/Internal Services/EC_DFU_DM: R204.1, U61.7 (D2-)
/Internal Services/EC_DFU_DP: R203.1, U61.3 (D2+)
/Internal Services/EC_USB_ISO_DM: R201.1, U61.6 (D-)
/Internal Services/EC_USB_ISO_DP: R200.1, U61.4 (D+)
/Internal Services/EC_USB_OE_N: Q60.3 (D), Q62.3 (D), R202.2, U61.9 (~OE)
/Internal Services/FAN_12V: C205.1, C206.1, F200.2, J52.2
/Internal Services/FAN_PWM_CONN: J52.4, Q200.3 (D)
/Internal Services/FAN_PWM_GATE: Q200.1 (G), R207.2, R208.1
/Internal Services/J73_CC1: J73.A5 (CC1), R205.1
/Internal Services/J73_CC2: J73.B5 (CC2), R211.1
/Internal Services/TPAD_5V: C283.1, J58.4, U64.6 (OUT)
/Internal Services/TPAD_CONN_DM: J58.2, R251.2, U62.2 (D1-)
/Internal Services/TPAD_CONN_DP: J58.3, R250.2, U62.1 (D1+)
/Internal Services/TPAD_ILIM: R252.1, U64.5 (ILIM)
/LID_CLOSED_N: J53.1, R209.2; also elsewhere on the board
/MCU_3V3: C208.1, J50.4, R202.1, R206.1, R209.1, R210.1, R215.1, R256.1, U60.5 (VBUS), U61.10 (VCC); also elsewhere on the board
/MCU_USB_DM: R201.2; also elsewhere on the board
/MCU_USB_DP: R200.2; also elsewhere on the board
/MU_12V: F200.1; also elsewhere on the board
/MU_HOST_ACTIVE: U64.3 (EN); also elsewhere on the board
/SYS_5V: C280.1, U64.1 (IN); also elsewhere on the board
/THERM_MU_ADC: C207.1, J56.1, R215.2; also elsewhere on the board
/THERM_SKIN_ADC: C202.1, J54.1, R210.2; also elsewhere on the board
/TRACKPAD_FAULT_N: R256.2, U64.4 (~FAULT); also elsewhere on the board
/TRACKPAD_USB_DM: R251.1; also elsewhere on the board
/TRACKPAD_USB_DP: R250.1; also elsewhere on the board
GND: C202.2, C205.2, C206.2, C207.2, C208.2, C209.2, C280.2, C283.2, J50.1, J52.1, J53.2, J54.2, J56.2, J58.1, J73.A1 (GND), J73.A12 (GND), J73.B1 (GND), J73.B12 (GND), J73.SH (SHIELD), Q60.2 (S), Q62.2 (S), Q200.2 (S), R205.2, R208.2, R211.2, R252.2, U60.2 (GND), U61.5 (GND), U62.3 (GND), U62.8 (GND), U63.2 (GND), U63.5 (VBUS), U64.2 (GND); also elsewhere on the board

Notes on the sheet:
== Internal laptop services: EC USB, trackpad, fan, lid, thermal ==
This sheet turns spare Mu USB2 ports and EC GPIO into internal laptop plumbing.
The internal display uses the Mu onboard eDP connector and needs no motherboard USB path.
== EC USB device link to host Mu USB2_P3 ==
== Rear USB-C EC firmware programming port (DFU) ==
BOOT0 (EC_DFU_SEL) high at EC reset selects this port and forces the USB mux on.
== Required internal trackpad on Mu USB2_P8 ==
J58 is four field-soldered pads for a cut USB 2.0 Standard-A-to-USB-C cable: 1=GND, 2=D-, 3=D+, 4=VBUS. The USB-C plug's compliant 56k Rp handles trackpad-side CC; U64 provides current limiting and host-off isolation.
== Fan, lid, and thermal service ==
NOTES:
EC enumerates over Mu USB2_P3 only after the carrier-generated physical INTERNAL_USB_VBUS is above the supervisor threshold. U61 defaults disconnected so an always-powered EC cannot back-drive an off host PHY.
The verified B160QAN03.K panel is non-touch; USB2_P4 is paired with native USB-C port 2.
Trackpad uses Mu USB2_P8 as a direct internal USB HID device. TRACKPAD_FAULT_N is pulled up to the EC; S3 removes trackpad VBUS, so wake-from-trackpad is not supported.
The Intehill controller remains a bench fixture/fallback and is not populated on the motherboard.
J52 is released for Delta BFB04512HHA-CZ0T: fused MU_12V, 8.2k/3.9n FG interface, and 25kHz open-drain PWM. Floating PWM commands full speed; firmware never drives the fan PWM node high.
Delta contract: 0.26A maximum, 35% minimum start duty, FG is open collector at 2 pulses/revolution, and 0% PWM stops the fan. Gate pull-down makes an unpowered/reset EC command full fan speed, not fan-off.
Thermal control has separate skin/hinge and Mu heatsink NTCs on ADC-capable EC pins.
The blower shares MU_12V: it is available whenever the Mu is powered. Thermal policy commands full fan and host throttle/shutdown before any final MU_12V cut; after a cut the passive coldplate/heatpipe/fin stack absorbs residual heat while heat generation is removed.
Cooling default is copper spreader/heatpipe/vapor chamber plus the released Delta blower; no Peltier/TEC in the base design. Solid-state AirJet-style modules are a future mechanical option only.

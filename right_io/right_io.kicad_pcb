# Repository EwoudVV/ducktop2 (continued)

## KiCad design ducktop2.kicad_pcb (continued)

Schematic: 02_ec_mcu.kicad_sch

Parts:
C20, C21, C22, C23, C24, C25, C31: 100n; C_0603_1608Metric; MPN GRM188R71H104KA93D
C26: 4.7u (bulk); C_0805_2012Metric; MPN GRM21BR71A475KA73L
C27: 100n (VBAT); C_0603_1608Metric; MPN GRM188R71H104KA93D
C28: 1u (VDDA); C_0805_2012Metric; MPN GRM21BR71A105KA01L
C29: 2.2u (VCAP_1, mandatory); C_0805_2012Metric; MPN GRM21BR60J225ME01
C30: 2.2u (VCAP_2, mandatory); C_0805_2012Metric; MPN GRM21BR60J225ME01
C32, C33: 10p C0G 0.25pF HSE load; C_0603_1608Metric; MPN C0603C100C5GACTU
C34, C35: 6.8p C0G 0.25pF LSE load; C_0603_1608Metric; MPN C0603C689C5GACTU
C36: 10u 50V X7R VIN; C_1206_3216Metric; MPN CGA5L1X7R1H106K160AC
C37: 100n 50V X7R VIN HF; C_0603_1608Metric; MPN GRM188R71H104KA93D
C38: 100n (BOOT cap); C_0603_1608Metric; MPN GRM188R71H104KA93D
C39, C291: 22u 16V X7R MCU_3V3 output; C_1206_3216Metric; MPN GRM31CZ71C226ME15L
C290: 10n (VDDA high-frequency); C_0603_1608Metric; MPN GRM188R71H103KA01
C292: 56p C0G TPS54202 feed-forward; C_0402_1005Metric; MPN GRM1555C1H560JA01
C780: 100n source-manager local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C781: 100n service-mux reset gate local; C_0603_1608Metric; MPN GRM188R71H104KA93D
J4: TC2030 Cortex SWD: VTref/SWDIO/NRST/SWCLK/GND/NC; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J16: Case power/reset button harness: GND/CASE_PWR/RES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; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal; MPN SM03B-SRSS-TB
L3: 10uH 20% 3.3A Isat20; Coilcraft_XGL5030; MPN XGL5030-103MEC
R32, R33: 10k; R_0603_1608Metric; MPN RC0603FR-0710KL
R34: 0R VTref sense link; R_0603_1608Metric; MPN RC0603FR-070RL
R35: 100k 1% (3.3V FB hi); R_0603_1608Metric; MPN RC0603FR-07100KL
R36: 22.1k 1% (3.3V FB lo); R_0603_1608Metric; MPN RC0603FR-0722K1L
R37: 0R HSE drive/tuning position; R_0603_1608Metric; MPN RC0603FR-070RL
R172: 100k service mux reset-request pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R212: 1k DFU select series; R_0603_1608Metric; MPN RC0603FR-071KL
R780: 10k source-manager INT pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R781: 10k aggregate AON fault pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R782: 100k HP_DETECT pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R783: 100k SLS_S3 default-low pull-down; R_0603_1608Metric; MPN RC0603FR-07100KL
SW1: Reset; SW_SPST_B3S-1000; MPN B3S-1000
SW4: BOOT0 (DFU); SW_SPST_B3S-1000; MPN B3S-1000
U4: STM32F407VGTx; LQFP-100_14x14mm_P0.5mm; MPN STM32F407VGT6
U5: TPS54202DDC; SOT-23-6; MPN TPS54202DDCR
U44: TCA9539PWR resettable source manager @0x74; TSSOP-24_4.4x7.8mm_P0.65mm; MPN TCA9539PWR
U46: SN74LVC1G08DBVR EC-reset-qualified service mux re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; SOT-23-5; MPN SN74LVC1G08DBVR
Y1: J32SMX-K-F-G-I-8M0 8MHz CL8pF; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN J32SMX-K-F-G-I-8M0
Y2: X1A000141000612 32.768kHz CL6pF; Crystal_SMD_3215-2Pin_3.2x1.5mm; MPN X1A000141000612

Connections:
/AON_FAULT_N: R781.2, U44.17 (IO1_4); also elsewhere on the board
/AUDIO_AMP_EC_EN: U4.43 (PE12); also elsewhere on the board
/AUDIO_MIC_EN: U4.42 (PE11); also elsewhere on the board
/AUX_DC_ADC: U4.31 (PA6); also elsewhere on the board
/AUX_FAULT_N: U44.11 (IO0_7); also elsewhere on the board
/AUX_PGOOD: U44.14 (IO1_1); also elsewhere on the board
/BQ_ALERT: U4.24 (PA1); also elsewhere on the board
/CASE_PWRBTN_N: J16.2; also elsewhere on the board
/CHG_ENABLE: U4.29 (PA4); also elsewhere on the board
/CHG_INT_N: U4.25 (PA2); also elsewhere on the board
/EC & MCU/BOOT0_NET: R33.1, R212.1, SW4.1, U4.94 (BOOT0)
/EC & MCU/BUCK_BOOT: C38.1, U5.6 (BOOT)
/EC & MCU/BUCK_FB: C292.2, R35.2, R36.1, U5.4 (FB)
/EC & MCU/BUCK_SW: C38.2, L3.1, U5.2 (SW)
/EC & MCU/EC_SWD_VTREF: J4.1, R34.2
/EC & MCU/HSE_IN: C32.1, U4.12 (PH0), Y1.1
/EC & MCU/HSE_OUT: R37.2, U4.13 (PH1)
/EC & MCU/HSE_XTAL_OUT: C33.1, R37.1, Y1.3
/EC & MCU/LSE_IN: C34.1, U4.8 (PC14), Y2.1
/EC & MCU/LSE_OUT: C35.1, U4.9 (PC15), Y2.2
/EC & MCU/NRST_NET: C31.1, J4.3, R32.2, SW1.1, U4.14 (NRST), U44.3 (~RESET), U46.1
/EC & MCU/SERVICE_MUX_RESET_REQ_N: R172.2, U4.51 (PB12), U46.2
/EC & MCU/SOURCE_MGR_INT_N: R780.2, U4.7 (PC13), U44.1 (~INT)
/EC & MCU/SWCLK_NET: J4.4, U4.76 (PA14)
/EC & MCU/SWDIO_NET: J4.2, U4.72 (PA13)
/EC & MCU/VCAP1_NODE: C29.1, U4.49 (VCAP_1)
/EC & MCU/VCAP2_NODE: C30.1, U4.73 (VCAP_2)
/EC_AON_IN: C36.1, C37.1, U5.3 (VIN); also elsewhere on the board
/EC_DFU_SEL: R212.2; also elsewhere on the board
/FAN_PWM: U4.40 (PE9); also elsewhere on the board
/FAN_TACH: U4.34 (PC5); also elsewhere on the board
/GNSS_EXTINT: U4.95 (PB8); also elsewhere on the board
/GNSS_PPS: U4.53 (PB14); also elsewhere on the board
/GNSS_RESET_N: U4.52 (PB13); also elsewhere on the board
/GNSS_UART_RX: U4.69 (PA10); also elsewhere on the board
/GNSS_UART_TX: U4.68 (PA9); also elsewhere on the board
/HP_DETECT: R782.2, U44.6 (IO0_2); also elsewhere on the board
/I2C_SCL: U4.92 (PB6), U44.22 (SCL); also elsewhere on the board
/I2C_SDA: U4.93 (PB7), U44.23 (SDA); also elsewhere on the board
/INTERNAL_USB_VBUS_FAULT_N: U4.89 (PB3); also elsewhere on the board
/KB_COL0: U4.81 (PD0); also elsewhere on the board
/KB_COL1: U4.82 (PD1); also elsewhere on the board
/KB_COL2: U4.83 (PD2); also elsewhere on the board
/KB_COL3: U4.84 (PD3); also elsewhere on the board
/KB_COL4: U4.85 (PD4); also elsewhere on the board
/KB_COL5: U4.86 (PD5); also elsewhere on the board
/KB_COL6: U4.87 (PD6); also elsewhere on the board
/KB_COL7: U4.88 (PD7); also elsewhere on the board
/KB_COL8: U4.55 (PD8); also elsewhere on the board
/KB_COL9: U4.56 (PD9); also elsewhere on the board
/KB_COL10: U4.57 (PD10); also elsewhere on the board
/KB_COL11: U4.58 (PD11); also elsewhere on the board
/KB_COL12: U4.59 (PD12); also elsewhere on the board
/KB_COL13: U4.60 (PD13); also elsewhere on the board
/KB_COL14: U4.61 (PD14); also elsewhere on the board
/KB_RGB_DATA_3V3: U4.62 (PD15); also elsewhere on the board
/KB_RGB_FAULT_N: U4.16 (PC1); also elsewhere on the board
/KB_RGB_PWR_EN: U4.15 (PC0); also elsewhere on the board
/KB_ROW0: U4.97 (PE0); also elsewhere on the board
/KB_ROW1: U4.98 (PE1); also elsewhere on the board
/KB_ROW2: U4.1 (PE2); also elsewhere on the board
/KB_ROW3: U4.2 (PE3); also elsewhere on the board
/KB_ROW4: U4.3 (PE4); also elsewhere on the board
/KB_ROW5: U4.4 (PE5); also elsewhere on the board
/KB_ROW6: U4.5 (PE6); also elsewhere on the board
/KB_ROW7: U4.38 (PE7); also elsewhere on the board
/LID_CLOSED_N: U4.41 (PE10); also elsewhere on the board
/MAIN_AUX_VALID_N: U44.16 (IO1_3); also elsewhere on the board
/MAIN_USB_VALID_N: U44.15 (IO1_2); also elsewhere on the board
/MCU_3V3: C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C39.1, C290.1, C291.1, C292.1, C780.1, C781.1, L3.2, R32.1, R34.1, R35.1, R172.1, R780.1, R781.1, R782.1, SW4.2, U4.6 (VBAT), U4.11 (VDD), U4.19 (VDD), U4.21 (VREF+), U4.22 (VDDA), U4.28 (VDD), U4.50 (VDD), U4.75 (VDD), U4.100 (VDD), U44.24 (V_{DD}), U46.5 (VCC); also elsewhere on the board
/MCU_USB_DM: U4.70 (PA11); also elsewhere on the board
/MCU_USB_DP: U4.71 (PA12); also elsewhere on the board
/MU_12V_ENABLE: U4.44 (PE13); also elsewhere on the board
/MU_12V_PG: U4.46 (PE15); also elsewhere on the board
/MU_PWRBTN_N: U4.23 (PA0); also elsewhere on the board
/MU_RSTBTN_N: J16.3, U4.30 (PA5); also elsewhere on the board
/MU_S0_HIGH: U4.45 (PE14); also elsewhere on the board
/PACK_FAULT_N: U44.10 (IO0_6); also elsewhere on the board
/PACK_RETRY_PULSE: U44.13 (IO1_0); also elsewhere on the board
/PD1_EFUSE_FAULT_N: U44.7 (IO0_3); also elsewhere on the board
/PD1_PATH_EN: U44.4 (IO0_0); also elsewhere on the board
/PD1_TCPC_IRQ_N: U4.39 (PE8); also elsewhere on the board
/PD1_VALID_N: U4.33 (PC4); also elsewhere on the board
/PD2_EFUSE_FAULT_N: U44.8 (IO0_4); also elsewhere on the board
/PD2_PATH_EN: U44.5 (IO0_1); also elsewhere on the board
/PD2_TCPC_IRQ_N: U4.90 (PB4); also elsewhere on the board
/PD2_VALID_N: U4.37 (PB2); also elsewhere on the board
/PD_PROTECT_FAULT_N: U4.96 (PB9); also elsewhere on the board
/PMIC_QON_ASSERT: U4.26 (PA3); also elsewhere on the board
/RADIO_DB_FAULT_N: U44.19 (IO1_6); also elsewhere on the board
/RADIO_DB_PG: U44.18 (IO1_5); also elsewhere on the board
/RADIO_DB_PRESENT_N: U44.20 (IO1_7); also elsewhere on the board
/RADIO_DB_PWR_EN: U4.91 (PB5); also elsewhere on the board
/RADIO_UHF_PD_N: U4.78 (PC10); also elsewhere on the board
/RADIO_UHF_PTT_N: U4.65 (PC8); also elsewhere on the board
/RADIO_UHF_RF_SEL_3V3: U4.18 (PC3); also elsewhere on the board
/RADIO_UHF_SQL: U4.80 (PC12); also elsewhere on the board
/RADIO_UHF_UART_RX: U4.64 (PC7); also elsewhere on the board
/RADIO_UHF_UART_TX: U4.63 (PC6); also elsewhere on the board
/RADIO_VHF_PD_N: U4.66 (PC9); also elsewhere on the board
/RADIO_VHF_PTT_N: U4.54 (PB15); also elsewhere on the board
/RADIO_VHF_RF_SEL_3V3: U4.17 (PC2); also elsewhere on the board
/RADIO_VHF_SQL: U4.79 (PC11); also elsewhere on the board
/RADIO_VHF_UART_RX: U4.48 (PB11); also elsewhere on the board
/RADIO_VHF_UART_TX: U4.47 (PB10); also elsewhere on the board
/SERVICE_MUX_RESET_N: U46.4; also elsewhere on the board
/SLS_S3: R783.1, U44.9 (IO0_5); also elsewhere on the board
/THERM_MU_ADC: U4.35 (PB0); also elsewhere on the board
/THERM_SKIN_ADC: U4.32 (PA7); also elsewhere on the board
/TRACKPAD_FAULT_N: U4.36 (PB1); also elsewhere on the board
/WIFI_W_DISABLE1_N_EC: U4.67 (PA8); also elsewhere on the board
/WIFI_W_DISABLE2_N_EC: U4.77 (PA15); also elsewhere on the board
GND: C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C39.2, C290.2, C291.2, C780.2, C781.2, J4.5, J16.1, R33.2, R36.2, R783.2, SW1.2, U4.10 (VSS), U4.20 (VSSA), U4.27 (VSS), U4.74 (VSS), U4.99 (VSS), U5.1 (GND), U44.2 (A1), U44.12 (V_{SS}), U44.21 (A0), U46.3 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board

Notes on the sheet:
-- Standard TC2030 Cortex SWD target pads --
EC_GPIOx numbering is a local convenience mapping - see U4 pin_nets for actual STM32 pin/net cross-ref.
NOTE: no wires used - connectivity is via matching label names (valid KiCad practice).
AUX_DC_ADC monitors the screw-terminal wide-DC input so firmware can classify and current-limit that source.
Anti-ghosting diodes for the keyboard matrix live on the separate MX ULP keyboard PCB.
-- U4 decoupling (one 100n per VDD pin, per datasheet) --
PE13 drives active-high MU_12V_ENABLE; PE14 reads MU_S0_HIGH; PE15 reads MU_12V_PG; PB1 reads TRACKPAD_FAULT_N.
U5 follows the TPS54202 3.3V table and runs from EC_AON_IN so source validation firmware can execute before arbitration.
== U5 TPS54202DDC EC_AON_IN -> MCU_3V3 Buck (3.3V, 2A) ==
EC can assert Mu PWRBTN_N/RSTBTN_N; J16 case power is diode-isolated to Mu PWRBTN and charger QON.
== Final case controls (no exposed EC/service-map headers) ==
The EC has no user GPIO header; all tinkering I/O is isolated to the integrated RP2350 maker domain.
-- HSE 8MHz + LSE 32.768kHz crystals --
U5 EN is intentionally floated: TI specifies an internal pull-up that enables the converter when EN is open.
== U4 STM32F407VGTx EC/MCU Core ==
== U44 resettable always-on source manager I/O expander ==
MCU_USB_DP/DM (PA12/PA11, OTG_FS device mode) are unrelated to the power-only USB-C PD sink ports.
-- NRST filter/button, BOOT0 strap --
Hardware UARTs: VHF USART3 on PB10/PB11, UHF USART6 on PC6/PC7, GNSS USART1 on PA9/PA10.
PA7/PB0 are thermal ADCs; fan PWM uses timer-capable PE9/TIM1_CH1 and tach remains EC-owned.

Schematic: 06_tcp0_external_hdmi.kicad_sch

Parts:
C150, C151, C152, C153, C154, C155, C156, C157: 100n 16V HDMI AC coupling; C_0402_1005Metric; MPN GRM155R71C104KA88D
C158: 1u 10V X7R HDMI 5V switch input; C_0805_2012Metric; MPN GRM188R71A105KA61D
C159: 1u 10V X7R HDMI 5V switch output; C_0805_2012Metric; MPN GRM188R71A105KA61D
C160: 100p PCA9306 VREF2/EN filter; C_0402_1005Metric; MPN GRM1555C1H101JA01D
C161: 100n HPD buffer local; C_0402_1005Metric; MPN GRM155R71A104KA01D
C162: 100n 10V X7R HDMI 5V switch input HF; C_0402_1005Metric; MPN GRM155R71A104KA01D
C163: 100n 10V X7R HDMI 5V switch output HF; C_0402_1005Metric; MPN GRM155R71A104KA01D
C164: 4.7n HDMI 5V switch rise-time; C_0402_1005Metric; MPN GRM155R71C472KA01D
C165: 4.7n HDMI 3V3 switch rise-time; C_0402_1005Metric; MPN GRM155R71C472KA01D
D150, D151, D152, D153, D154, D155, D156, D157: TPD1E0B04DPLR HDMI TMDS ESD (0.15pF max); D_0201_0603Metric; MPN TPD1E0B04DPLR
J30: External HDMI-A from TCP0; HDMI_A_Molex_208658-1001_Horizontal; MPN 208658-1001
Q50: BSS138 HDMI bias gate; SOT-23; MPN BSS138LT1G
R150, R151, R152, R153, R154, R155, R156, R157: 470R 1% HDMI bias; R_0402_1005Metric; MPN RC0402FR-07470RL
R158, R159: 2.2k HDMI DDC pull-up; R_0402_1005Metric; MPN RC0402FR-072K2L
R160, R161: 1.8k HDMI DDC pull-up; R_0402_1005Metric; MPN RC0402FR-071K8L
R162: 200k PCA9306 VREF2/EN bias; R_0402_1005Metric; MPN RC0402FR-07200KL
R163: 1k HPD input series; R_0402_1005Metric; MPN RC0402FR-071KL
R164: 100k HPD input pull-down; R_0402_1005Metric; MPN RC0402FR-07100KL
R165: 2.2k S0 bias-gate series; R_0402_1005Metric; MPN RC0402FR-072K2L
R166: 100k bias-gate default off; R_0402_1005Metric; MPN RC0402FR-07100KL
R167: 0R DNP HDMI bias always-on option; R_0402_1005Metric; not fitted
R168: 100k HDMI switched 5V discharge; R_0402_1005Metric; MPN RC0402FR-07100KL
R169: 100k HDMI switched 3V3 discharge; R_0402_1005Metric; MPN RC0402FR-07100KL
R570, R571, R572, R573, R574, R575, R576, R577, R578, R579: 75R 1% unused TPD13S523 channel termination; R_0402_1005Metric; MPN RC0402FR-0775RL
U50: TPD13S523PWR HDMI control ESD / 5V switch; TSSOP-16_4.4x5mm_P0.65mm; MPN TPD13S523PWR
U51: PCA9306DCTR HDMI DDC level translator; SSOP-8_2.95x2.8mm_P0.65mm; MPN PCA9306DCTR
U53: SN74LVC1G17DBVR HDMI HPD buffer; SOT-23-5; MPN SN74LVC1G17DBVR
U54: TPS22975NDSGR host-active SYS_5V switch; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN TPS22975NDSGR
U55: TPS22975NDSGR host-active SYS_3V3 switch; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN TPS22975NDSGR

Connections:
/MU_HOST_ACTIVE: R165.1, U54.3 (ON), U55.3 (ON); also elsewhere on the board
/SYS_3V3: U55.1 (VIN), U55.2 (VIN), U55.4 (VBIAS); also elsewhere on the board
/SYS_5V: U54.1 (VIN), U54.2 (VIN), U54.4 (VBIAS); also elsewhere on the board
/TCP0 External HDMI/EXT_HDMI_5V: C159.1, C163.1, J30.18 (+5V), R160.1, R161.1, R162.1, U50.6 (5V_OUT)
/TCP0 External HDMI/EXT_HDMI_BIAS_GATE: Q50.1 (G), R165.2, R166.1
/TCP0 External HDMI/EXT_HDMI_BIAS_RETURN: Q50.3 (D), R150.2, R151.2, R152.2, R153.2, R154.2, R155.2, R156.2, R157.2, R167.1
/TCP0 External HDMI/EXT_HDMI_CK_N: C157.2, D157.1 (A1), J30.12 (CK-), R157.1
/TCP0 External HDMI/EXT_HDMI_CK_P: C156.2, D156.1 (A1), J30.10 (CK+), R156.1
/TCP0 External HDMI/EXT_HDMI_D0_N: C155.2, D155.1 (A1), J30.9 (D0-), R155.1
/TCP0 External HDMI/EXT_HDMI_D0_P: C154.2, D154.1 (A1), J30.7 (D0+), R154.1
/TCP0 External HDMI/EXT_HDMI_D1_N: C153.2, D153.1 (A1), J30.6 (D1-), R153.1
/TCP0 External HDMI/EXT_HDMI_D1_P: C152.2, D152.1 (A1), J30.4 (D1+), R152.1
/TCP0 External HDMI/EXT_HDMI_D2_N: C151.2, D151.1 (A1), J30.3 (D2-), R151.1
/TCP0 External HDMI/EXT_HDMI_D2_P: C150.2, D150.1 (A1), J30.1 (D2+), R150.1
/TCP0 External HDMI/EXT_HDMI_HPD_CONN: J30.19 (HPD), R163.1, U50.3 (CTRL3)
/TCP0 External HDMI/EXT_HDMI_HPD_NODE: R163.2, R164.1, U53.2
/TCP0 External HDMI/EXT_HDMI_SCL_CONN: J30.15 (SCL), R160.2, U50.1 (CTRL1), U51.6 (SCL2)
/TCP0 External HDMI/EXT_HDMI_SDA_CONN: J30.16 (SDA), R161.2, U50.2 (CTRL2), U51.5 (SDA2)
/TCP0 External HDMI/HDMI_3V3_SWITCH_CT: C165.1, U55.6 (CT)
/TCP0 External HDMI/HDMI_5V_SWITCH_CT: C164.1, U54.6 (CT)
/TCP0 External HDMI/HDMI_DDC_REF5: C160.1, R162.2, U51.7 (VREF2), U51.8 (EN)
/TCP0 External HDMI/HDMI_HOST_3V3: C161.1, R158.1, R159.1, R169.1, U51.2 (VREF1), U53.5 (VCC), U55.7 (VOUT), U55.8 (VOUT)
/TCP0 External HDMI/HDMI_SOURCE_5V: C158.1, C162.1, R168.1, U50.5 (5V_SUPPLY), U54.7 (VOUT), U54.8 (VOUT)
/TCP0 External HDMI/HDMI_TPD_D0_UNUSED: R570.1, U50.4 (CTRL4)
/TCP0 External HDMI/HDMI_TPD_D1_UNUSED: R571.1, U50.7 (CTRL5)
/TCP0 External HDMI/HDMI_TPD_D2_UNUSED: R572.1, U50.9 (D3-)
/TCP0 External HDMI/HDMI_TPD_D3_UNUSED: R573.1, U50.10 (D3+)
/TCP0 External HDMI/HDMI_TPD_D4_UNUSED: R574.1, U50.11 (D2-)
/TCP0 External HDMI/HDMI_TPD_D5_UNUSED: R575.1, U50.12 (D2+)
/TCP0 External HDMI/HDMI_TPD_D6_UNUSED: R576.1, U50.13 (D1-)
/TCP0 External HDMI/HDMI_TPD_D7_UNUSED: R577.1, U50.14 (D1+)
/TCP0 External HDMI/HDMI_TPD_D8_UNUSED: R578.1, U50.15 (D0-)
/TCP0 External HDMI/HDMI_TPD_D9_UNUSED: R579.1, U50.16 (D0+)
/TCP0_DDC_SCL: R158.2, U51.3 (SCL1); also elsewhere on the board
/TCP0_DDC_SDA: R159.2, U51.4 (SDA1); also elsewhere on the board
/TCP0_HPD: U53.4; also elsewhere on the board
/TCP0_TX0_N: C151.1; also elsewhere on the board
/TCP0_TX0_P: C150.1; also elsewhere on the board
/TCP0_TX1_N: C155.1; also elsewhere on the board
/TCP0_TX1_P: C154.1; also elsewhere on the board
/TCP0_TXRX0_N: C153.1; also elsewhere on the board
/TCP0_TXRX0_P: C152.1; also elsewhere on the board
/TCP0_TXRX1_N: C157.1; also elsewhere on the board
/TCP0_TXRX1_P: C156.1; also elsewhere on the board
GND: C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, D150.2 (A2), D151.2 (A2), D152.2 (A2), D153.2 (A2), D154.2 (A2), D155.2 (A2), D156.2 (A2), D157.2 (A2), J30.2 (D2S), J30.5 (D1S), J30.8 (D0S), J30.11 (CKS), J30.17 (GND), J30.SH, Q50.2 (S), R164.2, R166.2, R167.2, R168.2, R169.2, R570.2, R571.2, R572.2, R573.2, R574.2, R575.2, R576.2, R577.2, R578.2, R579.2, U50.8 (GND), U51.1 (GND), U53.3 (GND), U54.5 (GND), U54.9 (EP), U55.5 (GND), U55.9 (EP); also elsewhere on the board

Notes on the sheet:
LattePanda Mu default BIOS maps TCP0 as HDMI 2.0; the internal panel uses the Mu module's onboard eDP connector.
TMDS ESD uses 0.15pF-max, +/-3.6V TPD1E0B04DPLR single-line parts; route each shunt at J30 with no stub.
LAYOUT: HDMI TMDS pairs are 100-ohm differential. Match pair skew to under 5 mil per Mu HDMI guide (current ~495 mil).
U54/U55 remove 5V/DDC/HPD power while the Mu is off; PCA9306 translates DDC/SCDC and U53 buffers HPD.
== J30 external HDMI-A connector ==
== TCP0 external HDMI 2.0 output ==
Release gate: verify >=4.8V at J30 pin 18 under 55mA and validate the finished HDMI 2.0 layout on hardware.
LAYOUT: PCIe Gen3 pairs are 85-ohm differential. Match data-pair skew under 5 mil and refclock under 5 mil per Mu PCIe guide.
Lane map, AC coupling, bias gating, DDC/HPD translation, and 5V isolation follow the Mu reference.
J30 is the outside-world HDMI jack. The retired Intehill controller is a bench-test/fallback fixture, not motherboard circuitry.
NOTES:
CEC and utility are explicitly NC; unused TPD13S523 legacy channels use the datasheet 75R-to-GND termination.

Board: 8 copper layers, 1225 parts (0 on the bottom side), 913 nets, no tracks yet.

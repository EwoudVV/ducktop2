# Repository EwoudVV/ducktop2 (continued)

## KiCad design ducktop2.kicad_pcb (continued)

Schematic: 03_mu_carrier.kicad_sch

Parts:
A1: TE 2309411-1 LattePanda Mu host socket/interface; LattePanda_Module_H8.0mm_Horizontal; MPN 2309411-1
A2: DFR1149 LattePanda Mu N305 16GB/64GB removable mo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; MPN DFR1149
C40, C41, C46, C776, C777, C790: 10u 50V X7R TPS56637 VIN; C_1206_3216Metric; MPN CGA5L1X7R1H106K160AC
C42, C778, C791: 100n 50V X7R TPS56637 VIN HF; C_0603_1608Metric; MPN GRM188R71H104KA93D
C43, C47, C779: 100n 16V X7R TPS56637 BOOT; C_0603_1608Metric; MPN C1608X7R1C104K080AA
C44, C45, C48, C792: 22u 16V X7R TPS56637 OUT; C_1206_3216Metric; MPN GRM31CZ71C226ME15L
C66, C67, C586, C587: 100n 10V X7R Mu USB3 TX AC; C_0402_1005Metric; MPN GRM155R71A104KA01D
C68, C69, C592, C593, C594, C595, C596, C597: 220n 10V X7R NVMe TX AC; C_0402_1005Metric; MPN GRM155R71A224KE01D
C590, C591: 220n 10V X7R Wi-Fi TX AC; C_0402_1005Metric; MPN GRM155R71A224KE01D
C750: 68u 50V hybrid input bulk; CP_Elec_8x10; MPN EEHZA1H680P
C751, C752: 10u 50V X7R input; C_1206_3216Metric; MPN CGA5L1X7R1H106K160AC
C753: 1u 50V X5R input; C_0603_1608Metric; MPN GRT188R61H105ME13D
C754, C755: 100n 50V X7R input HF; C_0402_1005Metric; MPN GRM155R71H104ME14D
C756, C757: 100n 50V X7R output HF; C_0402_1005Metric; MPN GRM155R71H104ME14D
C758: 1u 50V X5R output; C_0603_1608Metric; MPN GRT188R61H105ME13D
C759, C760, C761: 10u 50V X7R output; C_1206_3216Metric; MPN CGA5L1X7R1H106K160AC
C762: 100u 35V hybrid output bulk; CP_Elec_6.3x5.8; MPN EEHZK1V101XP
C763: 1u 50V post-sense load-side bypass; C_0603_1608Metric; MPN GRT188R61H105ME13D
C764: 22u 16V X7R VCC mandatory; effective >4.7u; C_1206_3216Metric; MPN GRM31CZ71C226ME15L
C765, C766: 100n 50V X8L bootstrap; C_0603_1608Metric; MPN GCM188L81H104KA57D
C767: 10n DITH/SYNC spreading; C_0603_1608Metric; MPN GRM188R71H103KA01
C768, C769: DNP 2.2n 250V X7R switch-node snubber; C_0805_2012Metric; MPN GRM21AR72E222KW01D; not fitted
C770: 100n differential current-sense filter; C_0603_1608Metric; MPN GRM188R71H104KA93D
C771: 4.7n COMP; C_0603_1608Metric; MPN GRM188R71H472KA01
C772: 100p C0G COMP HF; C_0603_1608Metric; MPN GRM1885C1H101JA01
C773: 100n UVLO noise filter; C_0603_1608Metric; MPN GRM188R71H104KA93D
C774: 10n PG deglitch; C_0603_1608Metric; MPN GRM188R71H103KA01
C775: 10n CC deglitch; C_0603_1608Metric; MPN GRM188R71H103KA01
C782: 47u 6.3V PCIE_3V3_IN rail bulk; C_1206_3216Metric; MPN GRM32ER60J476ME20L
C783: 1u RTC_BAT hold; C_0805_2012Metric; MPN GRM188R60J105KA01D
C793: 100n qualified host-active gate local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C794: 1u internal host VBUS switch input; C_0805_2012Metric; MPN GRM188R71A105KA61D
C830: 10u internal host VBUS output; C_1206_3216Metric; MPN GRM21BR61A106KE19L
C831: 100n TPS3897 VCC bypass; C_0603_1608Metric; MPN GRM188R71A104KA01D
C832: 1u PCIe endpoint switch input; C_0805_2012Metric; MPN GRM188R60J105KA01D
C833: 4.7n PCIe endpoint controlled slew; C_0402_1005Metric; MPN GRM155R71H472KA01D
C834: 47u 6.3V PCIe endpoint rail bulk; C_1206_3216Metric; MPN GRM32ER60J476ME20L
C835: 100n PCIe endpoint rail HF; C_0603_1608Metric; MPN GRM188R71A104KA01D
C836: 10u 6.3V NVMe socket local bulk; C_1206_3216Metric; MPN GRM21BR60J106ME19L
C837: 100n NVMe socket local HF; C_0603_1608Metric; MPN GRM188R71A104KA01D
D1824: 1N5819HW RTC_BAT diode-OR from MCU_3V3; Nexperia_CFP3_SOD-123W; MPN 1N5819HW
H1: Wurth 9774055243R Mu M2 standoff 5.5mm A; Wurth_9774055243R_M2_H5.5; MPN 9774055243R
H2: Wurth 9774055243R Mu M2 standoff 5.5mm B; Wurth_9774055243R_M2_H5.5; MPN 9774055243R
H3: M.2 M-key 2280 M2 grounded standoff 2.5mm; SMT_Standoff_M2_H2.5_C4_Tail2.7x1.5; MPN M2XC4X2.5+C2.7X1.5
H10, H11, H12, H13, H14, H15, H16, H17, H21, H22, H23, H24, H25, H26, H27: M2.5 isolated mainboard mounting hole; MountingHole_2.7mm_M2.5
J8: DNP Mu SIO UART debug header (3.3V, SIO console; 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; PinHeader_1x04_P2.54mm_Vertical; not fitted
J10: Amphenol MDT420M01001 M-key NVMe socket (PCIe x4); Amphenol_MDT420M01001_H4.2; MPN MDT420M01001
L4: XAL7070-332MEC 3.3uH 19.4A Isat30%; L_Coilcraft_XAL7070-XXX; MPN XAL7070-332MEC
L5, L1702: XAL7070-222MEC 2.2uH 19.6A Isat30%; L_Coilcraft_XAL7070-XXX; MPN XAL7070-222MEC
L750: 4.7uH 10.1A Isat / 6.9A Irms; L_Coilcraft_XAL7030-472; MPN XAL7030-472MEC
Q750: BSS138 fail-off EN/UVLO clamp; SOT-23; MPN BSS138LT1G
Q751: BSS138 active-high enable release; SOT-23; MPN BSS138LT1G
R40: 76.8k 0.1% TPS56637 FB high; R_0603_1608Metric; MPN RT0603BRD0776K8L
R41: 10k 0.1% TPS56637 FB low; R_0603_1608Metric; MPN RT0603BRD0710KL
R42, R770: 100k 1% TPS56637 EN high (host-active gate); R_0603_1608Metric; MPN RC0603FR-07169KL
R43: 45.3k 1% TPS56637 FB high; R_0603_1608Metric; MPN RC0603FR-0745K3L
R44: 10k 1% TPS56637 FB low; R_0603_1608Metric; MPN RC0603FR-0710KL
R45, R771: 100k 1% TPS56637 EN low; R_0603_1608Metric; MPN RC0603FR-0736K1L
R46: 100k SYS_5V PG pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R47: 0R / PERST isolation; R_0603_1608Metric; MPN RC0603FR-070RL
R48: 0R / REFCLK+ isolation; R_0603_1608Metric; MPN RC0603FR-070RL
R49: 0R / REFCLK- isolation; R_0603_1608Metric; MPN RC0603FR-070RL
R50: 1k NVMe CLKREQ# low: request REFCLK; R_0603_1608Metric; MPN RC0603FR-071KL
R750: 10R ISP Kelvin filter; R_0603_1608Metric; MPN RC0603FR-0710RL
R751: 10R ISN Kelvin filter; R_0603_1608Metric; MPN RC0603FR-0710RL
R752: 49.9R FB isolation; R_0603_1608Metric; MPN RC0603FR-0749R9L
R753: 102k 0.1% 12V FB high; R_0603_1608Metric; MPN RT0603BRD07102KL
R754: 11.3k 0.1% 12V FB low; R_0603_1608Metric; MPN RT0603BRD0711K3L
R755: 15k COMP series; R_0603_1608Metric; MPN RC0603FR-0715KL
R756: 49.9k 1% FSW = 400kHz; R_0603_1608Metric; MPN RC0603FR-0749K9L
R757: 0R MODE forced-PWM; R_0603_1608Metric; MPN RC0603FR-070RL
R758: 0R EXTVCC selects internal LDO; R_0603_1608Metric; MPN RC0603FR-070RL
R759: 150k 1% UVLO high; 9.0V rising; R_0603_1608Metric; MPN RC0603FR-07150KL
R760: 23.7k 1% UVLO low; R_0603_1608Metric; MPN RC0603FR-0723K7L
R761: 100k fail-off gate divider low; R_0603_1608Metric; MPN RC0603FR-07100KL
R762: 100k PG pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R763: 100k CC pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R764, R765: DNP 2.2R 0.25W switch-node snubber; R_1206_3216Metric; MPN ERJ-8RQF2R2V; not fitted
R766: 100k fail-off gate divider high; R_0603_1608Metric; MPN RC0603FR-07100KL
R767: 100k MU_12V_ENABLE reset pulldown; R_0603_1608Metric; MPN RC0603FR-07100KL
R768: 10k LattePanda PSON required pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R769: 100k MU_HOST_ACTIVE fail-low; R_0603_1608Metric; MPN RC0603FR-07100KL
R772: 100k SYS_3V3 PG pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R773: 43.2k 1% internal host VBUS 0.61A ILIM; R_0603_1608Metric; MPN RC0603FR-0743K2L
R774: 10k internal host VBUS fault pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R775: 10k internal host VBUS valid pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R776: 100k PCIe endpoint rail fail-low; R_0603_1608Metric; MPN RC0603FR-07100KL
R777: 78.7k 1% VBUS sense top divider; R_0603_1608Metric; MPN RC0603FR-0778K7L
R778: 10.0k 1% VBUS sense bottom divider; R_0603_1608Metric; MPN RC0603FR-0710KL
R779: 100k MU_SIO_UART_TX idle pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R784: 100k MU_SIO_UART_RX idle pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R785: 45.3k 1% TPS56637 FB high; R_0603_1608Metric; MPN RT0603BRD0745K3L
R786: 10k 1% TPS56637 FB low; R_0603_1608Metric; MPN RT0603BRD0710KL
R787: 100k 1% TPS56637 EN high (host-active gate); R_0603_1608Metric; MPN RC0603FR-07100KL
R788: 100k 1% TPS56637 EN low; R_0603_1608Metric; MPN RC0603FR-07100KL
R789: 100k PCIE_3V3_PG pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
RS750: 15mOhm 1% 1W; 3.33A output current limit; R_1206_3216Metric; MPN ERJ8BWFR015V
SW2: Mu Power; SW_SPST_B3S-1000; MPN B3S-1000
SW3: Mu Reset; SW_SPST_B3S-1000; MPN B3S-1000
TP5: SYS_5V test; TestPoint_Pad_D1.0mm
TP6: SYS_3V3 test; TestPoint_Pad_D1.0mm
TP8: MU_12V test; TestPoint_Pad_D1.0mm
TP12: MU_12V_PG test; TestPoint_Pad_D1.0mm
TP13: Internal USB VBUS test; TestPoint_Pad_D1.0mm
TP14: Internal USB VBUS valid test; TestPoint_Pad_D1.0mm
TP15: Internal USB VBUS fault test; TestPoint_Pad_D1.0mm
TP16: Mu SIO UART TX probe pad; TestPoint_Pad_D1.0mm
TP17: Mu SIO UART RX probe pad; TestPoint_Pad_D1.0mm
U6: TPS56637RPAR VSYS -> SYS_5V (5.10V, 6A class); Texas_RPA0010A_VQFN-HR-10_3x3mm; MPN TPS56637RPAR
U7: TPS56637RPAR VSYS -> SYS_3V3 (3.32V, 6A class); Texas_RPA0010A_VQFN-HR-10_3x3mm; MPN TPS56637RPAR
U750: TPS552892RYQR 12V buck-boost; Texas_RYQ0021A_VQFN-HR-21_3x5mm; MPN TPS552892RYQR
U769: SN74LVC1G08DBVR qualified host-active AND; SOT-23-5; MPN SN74LVC1G08DBVR
U770: TPS2553DDBVR internal host VBUS 0.61A; SOT-23-6; MPN TPS2553DDBVR
U771: TPS3897ADRYR internal VBUS supervisor (always-pow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; Texas_USON-6_1x1.45mm_P0.5mm_SMD; MPN TPS3897ADRYR
U772: TPS22975NDSGR switched PCIe endpoint 3V3; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN TPS22975NDSGR
U773: TPS56637RPAR VSYS -> PCIE_3V3_IN (3.32V, 6A class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; Texas_RPA0010A_VQFN-HR-10_3x3mm; MPN TPS56637RPAR

Connections:
/AUDIO_USB_DM: A1.109 (USB2_P5-); also elsewhere on the board
/AUDIO_USB_DP: A1.111 (USB2_P5+); also elsewhere on the board
/EC_HOST_USB_DM: A1.79 (USB2_P3-); also elsewhere on the board
/EC_HOST_USB_DP: A1.81 (USB2_P3+); also elsewhere on the board
/FAN_TACH: A1.4 (FAN1_TAC); also elsewhere on the board
/GBE_CLKREQ_N: A1.102 (~CLKREQ4); also elsewhere on the board
/GBE_HOST_RX_N: A1.66 (HSIO6_RX-); also elsewhere on the board
/GBE_HOST_RX_P: A1.64 (HSIO6_RX+); also elsewhere on the board
/GBE_HOST_TX_N: A1.63 (HSIO6_TX-); also elsewhere on the board
/GBE_HOST_TX_P: A1.61 (HSIO6_TX+); also elsewhere on the board
/GBE_REFCLK_N: A1.96 (REFCLK4-); also elsewhere on the board
/GBE_REFCLK_P: A1.94 (REFCLK4+); also elsewhere on the board
/INTERNAL_USB_VBUS_FAULT_N: R774.2, TP15.1 (1_1), U770.4 (~FAULT); also elsewhere on the board
/INTERNAL_USB_VBUS_VALID: R775.2, TP14.1 (1_1), U771.4 (SENSE_OUT); also elsewhere on the board
/MAKER_USB_DM: A1.78 (USB2_P7-); also elsewhere on the board
/MAKER_USB_DP: A1.76 (USB2_P7+); also elsewhere on the board
/MCU_3V3: C793.1, C831.1, D1824.1 (K), R46.1, R762.1, R768.1, R772.1, R774.1, R775.1, R779.1, R784.1, R789.1, U769.5 (VCC), U771.1 (ENABLE), U771.6 (VCC); also elsewhere on the board
/MU_12V: A1.250 (VIN), A1.251 (VIN), A1.252 (VIN), A1.253 (VIN), A1.254 (VIN), A1.255 (VIN), A1.256 (VIN), A1.257 (VIN), A1.258 (VIN), A1.259 (VIN), A1.260 (VIN), C763.1, R751.1, R752.1, RS750.2, TP8.1 (1_1); also elsewhere on the board
/MU_12V_ENABLE: Q751.1 (G), R767.1; also elsewhere on the board
/MU_12V_PG: C774.1, R762.2, TP12.1 (1_1), U750.3 (PG), U769.2; also elsewhere on the board
/MU_HOST_ACTIVE: R42.1, R769.1, R770.1, R776.1, R787.1, U769.4, U770.3 (EN), U772.3 (ON); also elsewhere on the board
/MU_PWRBTN_N: A1.1 (~PWRBTN), SW2.1; also elsewhere on the board
/MU_RSTBTN_N: A1.3 (~RSTBTN), SW3.1; also elsewhere on the board
/MU_S0_HIGH: A1.5 (PSON), R768.2, U769.1; also elsewhere on the board
/Mu Carrier/BUCK5_BOOT: C43.1, U6.7 (BOOT)
/Mu Carrier/BUCK5_EN: R42.2, R45.1, U6.1 (EN)
/Mu Carrier/BUCK5_FB: R40.2, R41.1, U6.2 (FB)
/Mu Carrier/BUCK5_SW: C43.2, L4.1, U6.6 (SW)
/Mu Carrier/BUCK33_BOOT: C47.1, U7.7 (BOOT)
/Mu Carrier/BUCK33_EN: R770.2, R771.1, U7.1 (EN)
/Mu Carrier/BUCK33_FB: R43.2, R44.1, U7.2 (FB)
/Mu Carrier/BUCK33_SW: C47.2, L5.1, U7.6 (SW)
/Mu Carrier/BUCKPE_BOOT: C779.1, U773.7 (BOOT)
/Mu Carrier/BUCKPE_EN: R787.2, R788.1, U773.1 (EN)
/Mu Carrier/BUCKPE_FB: R785.2, R786.1, U773.2 (FB)
/Mu Carrier/BUCKPE_SW: C779.2, L1702.1, U773.6 (SW)
/Mu Carrier/INTERNAL_USB_VBUS: C830.1, R777.1, TP13.1 (1_1), U770.6 (OUT)
/Mu Carrier/INTERNAL_USB_VBUS_ILIM: R773.1, U770.5 (ILIM)
/Mu Carrier/INTERNAL_USB_VBUS_SENSE: R777.2, R778.1, U771.3 (SENSE)
/Mu Carrier/MU12_BOOT1: C765.1, U750.20 (BOOT1)
/Mu Carrier/MU12_BOOT2: C766.1, U750.19 (BOOT2)
/Mu Carrier/MU12_CC_N: C775.1, R763.2, U750.4 (~CC)
/Mu Carrier/MU12_COMP: C772.1, R755.1, U750.15 (COMP)
/Mu Carrier/MU12_COMP_RC: C771.1, R755.2
/Mu Carrier/MU12_DITH: C767.1, U750.5 (DITH/SYNC)
/Mu Carrier/MU12_EN_UVLO: C773.1, Q750.3 (D), R759.2, R760.1, U750.1 (EN/UVLO)
/Mu Carrier/MU12_EXTVCC: R758.2, U750.21 (EXTVCC)
/Mu Carrier/MU12_FB: R753.2, R754.1, U750.14 (FB)
/Mu Carrier/MU12_FB_TOP: R752.2, R753.1
/Mu Carrier/MU12_FORCE_OFF: Q750.1 (G), Q751.3 (D), R761.1, R766.2
/Mu Carrier/MU12_FSW: R756.1, U750.6 (FSW)
/Mu Carrier/MU12_ISN: C770.2, R751.2, U750.13 (ISN)
/Mu Carrier/MU12_ISP: C770.1, R750.2, U750.12 (ISP)
/Mu Carrier/MU12_MODE: R757.2, U750.2 (MODE)
/Mu Carrier/MU12_PRE_SENSE: C756.1, C757.1, C758.1, C759.1, C760.1, C761.1, C762.1, R750.1, RS750.1, U750.11 (VOUT)
/Mu Carrier/MU12_SNUB1: C768.1, R764.2
/Mu Carrier/MU12_SNUB2: C769.1, R765.2
/Mu Carrier/MU12_SW1: C765.2, L750.1, R764.1, U750.8 (SW1)
/Mu Carrier/MU12_SW2: C766.2, L750.2, R765.1, U750.10 (SW2)
/Mu Carrier/MU12_VCC: C764.1, R757.1, R758.1, R763.1, U750.18 (VCC)
/Mu Carrier/MU_SIO_UART_RX: A1.12 (SIO_UART_RX), J8.3, R784.2, TP17.1
/Mu Carrier/MU_SIO_UART_TX: A1.10 (SIO_UART_TX), J8.2, R779.2, TP16.1
/Mu Carrier/PCIE_3V3_CT: C833.1, U772.6 (CT)
/Mu Carrier/PCIE_3V3_IN: C782.1, C832.1, L1702.2, R785.1, U772.1 (VIN), U772.2 (VIN), U772.4 (VBIAS)
/Mu Carrier/PCIE_3V3_PG: R789.2, U773.4 (PG)
/Mu Carrier/PCIE_M_CLKREQ_N: J10.52 (~CLKREQ), R50.1
/Mu Carrier/PCIE_M_L0_RX_N: A1.42 (HSIO8_RX-), J10.41 (PERn0/SATA-B+)
/Mu Carrier/PCIE_M_L0_RX_P: A1.40 (HSIO8_RX+), J10.43 (PERp0/SATA-B-)
/Mu Carrier/PCIE_M_L0_TX_N: C69.2, J10.47 (PETn0/SATA-A-)
/Mu Carrier/PCIE_M_L0_TX_P: C68.2, J10.49 (PETp0/SATA-A+)
/Mu Carrier/PCIE_M_L0_TX_RAW_N: A1.39 (HSIO8_TX-), C69.1
/Mu Carrier/PCIE_M_L0_TX_RAW_P: A1.37 (HSIO8_TX+), C68.1
/Mu Carrier/PCIE_M_L1_RX_N: A1.48 (HSIO9_RX-), J10.29 (PERn1)
/Mu Carrier/PCIE_M_L1_RX_P: A1.46 (HSIO9_RX+), J10.31 (PERp1)
/Mu Carrier/PCIE_M_L1_TX_N: C593.2, J10.35 (PETn1)
/Mu Carrier/PCIE_M_L1_TX_P: C592.2, J10.37 (PETp1)
/Mu Carrier/PCIE_M_L1_TX_RAW_N: A1.45 (HSIO9_TX-), C593.1
/Mu Carrier/PCIE_M_L1_TX_RAW_P: A1.43 (HSIO9_TX+), C592.1
/Mu Carrier/PCIE_M_L2_RX_N: A1.54 (HSIO10_RX-), J10.17 (PERn2)
/Mu Carrier/PCIE_M_L2_RX_P: A1.52 (HSIO10_RX+), J10.19 (PERp2)
/Mu Carrier/PCIE_M_L2_TX_N: C595.2, J10.23 (PETn2)
/Mu Carrier/PCIE_M_L2_TX_P: C594.2, J10.25 (PETp2)
/Mu Carrier/PCIE_M_L2_TX_RAW_N: A1.51 (HSIO10_TX-), C595.1
/Mu Carrier/PCIE_M_L2_TX_RAW_P: A1.49 (HSIO10_TX+), C594.1
/Mu Carrier/PCIE_M_L3_RX_N: A1.60 (HSIO11_RX-), J10.5 (PERn3)
/Mu Carrier/PCIE_M_L3_RX_P: A1.58 (HSIO11_RX+), J10.7 (PERp3)
/Mu Carrier/PCIE_M_L3_TX_N: C597.2, J10.11 (PETn3)
/Mu Carrier/PCIE_M_L3_TX_P: C596.2, J10.13 (PETp3)
/Mu Carrier/PCIE_M_L3_TX_RAW_N: A1.57 (HSIO11_TX-), C597.1
/Mu Carrier/PCIE_M_L3_TX_RAW_P: A1.55 (HSIO11_TX+), C596.1
/Mu Carrier/PCIE_M_PERST_N: J10.50 (~PERST), R47.2
/Mu Carrier/PCIE_M_REFCLK_N: J10.53 (REFCLKn), R49.2
/Mu Carrier/PCIE_M_REFCLK_P: J10.55 (REFCLKp), R48.2
/Mu Carrier/PCIE_M_REFCLK_SRC_N: A1.99 (REFCLK2-), R49.1
/Mu Carrier/PCIE_M_REFCLK_SRC_P: A1.97 (REFCLK2+), R48.1
/Mu Carrier/RTC_BAT: A1.115 (VBAT), C783.1, D1824.2 (A)
/Mu Carrier/SYS_3V3_PG: R772.2, U7.4 (PG)
/Mu Carrier/SYS_5V_PG: R46.2, U6.4 (PG)
/Mu Carrier/USBC1_SSTX_RAW_N: A1.15 (HSIO0_TX-), C67.1
/Mu Carrier/USBC1_SSTX_RAW_P: A1.13 (HSIO0_TX+), C66.1
/Mu Carrier/USBC2_SSTX_RAW_N: A1.21 (HSIO1_TX-), C587.1
/Mu Carrier/USBC2_SSTX_RAW_P: A1.19 (HSIO1_TX+), C586.1
/Mu Carrier/WIFI_PCIE_TX_RAW_N: A1.33 (HSIO3_TX-), C591.1
/Mu Carrier/WIFI_PCIE_TX_RAW_P: A1.31 (HSIO3_TX+), C590.1
/PCIE_3V3: C834.1, C835.1, C836.1, C837.1, J10.2 (3.3V), J10.4 (3.3V), J10.12 (3.3V), J10.14 (3.3V), J10.16 (3.3V), J10.18 (3.3V), J10.70 (3.3V), J10.72 (3.3V), J10.74 (3.3V), U772.7 (VOUT), U772.8 (VOUT); also elsewhere on the board
/PCIE_WAKE_N: A1.103 (~WAKE), J10.54 (~PEWAKE); also elsewhere on the board
/PD_PROTECT_FAULT_N: A1.129 (~USB_OC); also elsewhere on the board
/PLTRST_SRC_N: A1.105 (~PLTRST), R47.1; also elsewhere on the board
/SLS_S3: A1.7 (SLS_S3); also elsewhere on the board
/SYS_3V3: C48.1, C792.1, L5.2, R43.1, TP6.1 (1_1); also elsewhere on the board
/SYS_5V: C44.1, C45.1, C794.1, L4.2, R40.1, TP5.1 (1_1), U770.1 (IN); also elsewhere on the board
/TCP0_DDC_SCL: A1.179 (TCP0_DDC_SCL); also elsewhere on the board
/TCP0_DDC_SDA: A1.177 (TCP0_DDC_SDA); also elsewhere on the board
/TCP0_HPD: A1.187 (TCP0_HPD); also elsewhere on the board
/TCP0_TX0_N: A1.245 (TCP0_TX0-); also elsewhere on the board
/TCP0_TX0_P: A1.247 (TCP0_TX0+); also elsewhere on the board
/TCP0_TX1_N: A1.233 (TCP0_TX1-); also elsewhere on the board
/TCP0_TX1_P: A1.235 (TCP0_TX1+); also elsewhere on the board
/TCP0_TXRX0_N: A1.239 (TCP0_TXRX0-); also elsewhere on the board
/TCP0_TXRX0_P: A1.241 (TCP0_TXRX0+); also elsewhere on the board
/TCP0_TXRX1_N: A1.227 (TCP0_TXRX1-); also elsewhere on the board
/TCP0_TXRX1_P: A1.229 (TCP0_TXRX1+); also elsewhere on the board
/TRACKPAD_USB_DM: A1.84 (USB2_P8-); also elsewhere on the board
/TRACKPAD_USB_DP: A1.82 (USB2_P8+); also elsewhere on the board
/USBC1_DM: A1.73 (USB2_P2-); also elsewhere on the board
/USBC1_DP: A1.75 (USB2_P2+); also elsewhere on the board
/USBC1_SSRX_N: A1.18 (HSIO0_RX-); also elsewhere on the board
/USBC1_SSRX_P: A1.16 (HSIO0_RX+); also elsewhere on the board
/USBC1_SSTX_N: C67.2; also elsewhere on the board
/USBC1_SSTX_P: C66.2; also elsewhere on the board
/USBC2_DM: A1.72 (USB2_P4-); also elsewhere on the board
/USBC2_DP: A1.70 (USB2_P4+); also elsewhere on the board
/USBC2_SSRX_N: A1.24 (HSIO1_RX-); also elsewhere on the board
/USBC2_SSRX_P: A1.22 (HSIO1_RX+); also elsewhere on the board
/USBC2_SSTX_N: C587.2; also elsewhere on the board
/USBC2_SSTX_P: C586.2; also elsewhere on the board
/VSYS: C40.1, C41.1, C42.1, C46.1, C750.1, C751.1, C752.1, C753.1, C754.1, C755.1, C776.1, C777.1, C778.1, C790.1, C791.1, R759.1, R766.1, U6.8 (VIN), U7.8 (VIN), U750.7 (VIN), U773.8 (VIN); also elsewhere on the board
/WIFI_CLKREQ_N: A1.100 (~CLKREQ3); also elsewhere on the board
/WIFI_PCIE_RX_N: A1.36 (HSIO3_RX-); also elsewhere on the board
/WIFI_PCIE_RX_P: A1.34 (HSIO3_RX+); also elsewhere on the board
/WIFI_PCIE_TX_N: C591.2; also elsewhere on the board
/WIFI_PCIE_TX_P: C590.2; also elsewhere on the board
/WIFI_REFCLK_N: A1.90 (REFCLK3-); also elsewhere on the board
/WIFI_REFCLK_P: A1.88 (REFCLK3+); also elsewhere on the board
/WIFI_USB_DN: A1.67 (USB2_P1-); also elsewhere on the board
/WIFI_USB_DP: A1.69 (USB2_P1+); also elsewhere on the board
GND: A1.11 (GND), A1.14 (GND), A1.17 (GND), A1.20 (GND), A1.23 (GND), A1.26 (GND), A1.29 (GND), A1.32 (GND), A1.35 (GND), A1.38 (GND), A1.41 (GND), A1.44 (GND), A1.47 (GND), A1.50 (GND), A1.53 (GND), A1.56 (GND), A1.59 (GND), A1.62 (GND), A1.65 (GND), A1.68 (GND), A1.71 (GND), A1.74 (GND), A1.77 (GND), A1.80 (GND), A1.83 (GND), A1.86 (GND), A1.89 (GND), A1.92 (GND), A1.95 (GND), A1.98 (GND), A1.101 (GND), A1.107 (GND), A1.110 (GND), A1.113 (GND), A1.116 (GND), A1.135 (GND), A1.136 (GND), A1.151 (GND), A1.158 (GND), A1.167 (GND), A1.170 (GND), A1.181 (GND), A1.182 (GND), A1.188 (GND), A1.189 (GND), A1.194 (GND), A1.195 (GND), A1.200 (GND), A1.201 (GND), A1.206 (GND), A1.207 (GND), A1.212 (GND), A1.213 (GND), A1.218 (GND), A1.219 (GND), A1.224 (GND), A1.225 (GND), A1.230 (GND), A1.231 (GND), A1.236 (GND), A1.237 (GND), A1.242 (GND), A1.243 (GND), A1.248 (GND), A1.249 (GND), A1.MP (Mountinge_Pads), C40.2, C41.2, C42.2, C44.2, C45.2, C46.2, C48.2, C750.2, C751.2, C752.2, C753.2, C754.2, C755.2, C756.2, C757.2, C758.2, C759.2, C760.2, C761.2, C762.2, C763.2, C764.2, C767.2, C768.2, C769.2, C771.2, C772.2, C773.2, C774.2, C775.2, C776.2, C777.2, C778.2, C782.2, C783.2, C790.2, C791.2, C792.2, C793.2, C794.2, C830.2, C831.2, C832.2, C833.2, C834.2, C835.2, C836.2, C837.2, H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), J8.1, J8.4, J10.1 (GND), J10.3 (GND), J10.9 (GND), J10.15 (GND), J10.21 (GND), J10.27 (GND), J10.33 (GND), J10.39 (GND), J10.45 (GND), J10.51 (GND), J10.57 (GND), J10.71 (GND), J10.73 (GND), J10.75 (GND), Q750.2 (S), Q751.2 (S), R41.2, R44.2, R45.2, R50.2, R754.2, R756.2, R760.2, R761.2, R767.2, R769.2, R771.2, R773.2, R776.2, R778.2, R786.2, R788.2, SW2.2, SW3.2, U6.3 (AGND), U6.9 (PGND), U6.10 (MODE), U7.3 (AGND), U7.9 (PGND), U7.10 (MODE), U750.9 (PGND), U750.17 (AGND), U769.3 (GND), U770.2 (GND), U771.2 (GND), U772.5 (GND), U772.9 (EP), U773.3 (AGND), U773.9 (PGND), U773.10 (MODE); also elsewhere on the board

Notes on the sheet:
== A1 LattePanda Mu carrier core ==
== Local carrier rails from VSYS ==
== U750 TPS552892 VSYS -> regulated MU_12V, 12 V / 3.3 A limit ==
== J10 M.2 M-key NVMe, default-BIOS PCIe Gen3 x4 ==
NOTES:
Mu VIN and onboard eDP BL_PWR use regulated MU_12V; the exact B160QAN03.K harness/pinout remains a release gate.
Default-BIOS HSIO0/1 are independent native USB 3.2 Gen2 ports; HSIO3 + USB2_P1 feed M.2 E-key.
The verified B160QAN03.K panel connects to the Mu onboard eDP connector; DDIB is unused.
TCP0 HDMI 2.0 lane/HPD/DDC nets leave to sheet 6 for the external HDMI-A output.
USB2_P3 is EC; P4 pairs with USB-C 2; P5 is the system-audio hub; P7 is maker MCU; P8 is trackpad.
Native USB-C data/OC nets leave to sheet 4; VBUS switching, CC, muxing, and ESD live there.
SYS_5V and SYS_3V3 use TPS56637 6A-class bucks with XAL7070 inductors; endpoint load budgets remain a release check.
M.2 M-key uses default HSIO8-11 x4 and REFCLK2; no lane reversal and no TX/RX direction swap.
M.2 M-key: Mu TX->PET through 220n near J10; PET/PER naming is from the host perspective.
USB2_P6 is reserved for the Mu Type-C PD controller direction; trackpad consumes the former USB2_P8 spare.
MU_12V is a TPS552892EVM-derived 12V stage: 400kHz forced PWM, 3.33A nominal limit, and about 8.65-9.40V worst-case rising UVLO. Firmware requires VSYS >=10.0V.
MU_12V_ENABLE is active high and defaults low. Q750/Q751 force EN/UVLO low until EC firmware explicitly releases the rail; MU_12V_PG is pulled up to MCU_3V3.
POWER BUDGET HOLD: MU_12V is about 40W maximum for Mu plus eDP backlight. Lock BIOS PL1/PL2 only after measuring panel and whole-module draw; unrestricted 35W CPU mode is not released.
MU_S0_HIGH is Mu PSON with the required 10k pull-up to always-on MCU_3V3. It is a weak status signal for logic/NMOS gates only, never a load supply.
SLEEP POLICY: PSON is low in S3, so PCIe endpoint 3V3, user USB-C VBUS, trackpad, maker USB, and internal audio detach. Wake from those devices is intentionally unsupported.
MECHANICAL: the 8.0mm standard-orientation TE 2309411-1 socket requires two grounded 5.5mm M2 standoffs at H1/H2; SO-DIMM clips alone are not structural retention.
MECHANICAL: H3 is the grounded 2280 retainer for the 4.2mm M-key socket. H10-H17 are isolated M2.5 chassis holes; chassis bonding is a separate controlled point.

Schematic: 09_radio_daughterboard_interface.kicad_sch

Parts:
C2300: 4.7n radio eFuse controlled rise; C_0402_1005Metric; MPN GRM155R71H472KA01
C2301: 10u SYS_5V radio eFuse input; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C2302: 100n SYS_5V radio eFuse input HF; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2303: 22u RADIO_DB_5V output bulk; C_1206_3216Metric; MPN GRM31CZ71C226ME15L
C2304: 100n RADIO_DB_5V output HF; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2305: 100n radio PG buffer local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2306: 100n USB switch local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C2307: 1u radio codec VBUS gate input; C_0805_2012Metric; MPN GRM21BR71E105KA12L
C2308: 10u radio codec VBUS gate output; C_1206_3216Metric; MPN GRM31CR71E106KA12L
J2300: FH12-30S 30-pin radio daughterboard FFC; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal; MPN FH12-30S-0.5SH(55)
Q2300: 2N7002K radio-PG USB enable; SOT-23; MPN 2N7002KT1G
R2300: 100k radio eFuse enable pulldown; R_0603_1608Metric; MPN RC0603FR-07100KL
R2301: 1.65k 0.1% radio eFuse ILM about 2.0A; R_0603_1608Metric; MPN RT0603BRD071K65L
R2302: 2.2k supervisor pull-up to switched 5V; R_0603_1608Metric; MPN RC0603FR-072K2L
R2303: 10k radio PG level-divider top; R_0603_1608Metric; MPN RC0603FR-0710KL
R2304: 20k radio PG level-divider bottom; R_0603_1608Metric; MPN RC0603FR-0720KL
R2305: 10k radio eFuse/shared fault pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R2306: 10k daughterboard-present pull-up; absent=high; R_0603_1608Metric; MPN RC0603FR-0710KL
R2307: 100k USB switch disable pull-up; R_0603_1608Metric; MPN RC0603FR-07100KL
R2308: 133k 1% TPS2553 current limit about 0.20A; R_0603_1608Metric; MPN RC0603FR-07133KL
R2310: 10k VHF PTT inactive; R_0603_1608Metric; MPN RC0603FR-0710KL
R2311: 10k UHF PTT inactive; R_0603_1608Metric; MPN RC0603FR-0710KL
R2312: 10k VHF asleep; R_0603_1608Metric; MPN RC0603FR-0710KL
R2313: 10k UHF asleep; R_0603_1608Metric; MPN RC0603FR-0710KL
R2314: 100k VHF internal antenna; R_0603_1608Metric; MPN RC0603FR-07100KL
R2315: 100k UHF internal antenna; R_0603_1608Metric; MPN RC0603FR-07100KL
R2316: 100k VHF UART idle-high while absent; R_0603_1608Metric; MPN RC0603FR-07100KL
R2317: 100k UHF UART idle-high while absent; R_0603_1608Metric; MPN RC0603FR-07100KL
R2318: 100k GNSS RX idle-high while absent; R_0603_1608Metric; MPN RC0603FR-07100KL
R2319: 100k GNSS reset released while absent; R_0603_1608Metric; MPN RC0603FR-07100KL
R2320: 100k VHF RX default low while daughterboard absent; R_0603_1608Metric; MPN RC0603FR-07100KL
R2321: 100k UHF RX default low while daughterboard absent; R_0603_1608Metric; MPN RC0603FR-07100KL
R2322: 100k VHF SQL default low while daughterboard abse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; R_0603_1608Metric; MPN RC0603FR-07100KL
R2323: 100k UHF SQL default low while daughterboard abse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; R_0603_1608Metric; MPN RC0603FR-07100KL
R2324: 100k GNSS TX default low while daughterboard abse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; R_0603_1608Metric; MPN RC0603FR-07100KL
R2325: 100k GNSS PPS default low while daughterboard abs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; R_0603_1608Metric; MPN RC0603FR-07100KL
R2326: 100k GNSS EXTINT default low while daughterboard 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; R_0603_1608Metric; MPN RC0603FR-07100KL
R2340: 4.7k J2300 pin 11 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2341: 4.7k J2300 pin 12 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2342: 4.7k J2300 pin 13 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2343: 4.7k J2300 pin 14 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2344: 4.7k J2300 pin 15 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2345: 4.7k J2300 pin 16 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2346: 4.7k J2300 pin 17 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2347: 4.7k J2300 pin 18 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2348: 4.7k J2300 pin 20 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2349: 4.7k J2300 pin 21 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2350: 4.7k J2300 pin 22 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2351: 4.7k J2300 pin 23 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2352: 4.7k J2300 pin 24 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2353: 4.7k J2300 pin 25 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2354: 4.7k J2300 pin 27 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2355: 4.7k J2300 pin 28 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
R2356: 4.7k J2300 pin 29 signal isolation; R_0603_1608Metric; MPN RC0603FR-074K7L
U2300: TPS259470ARPW 2A reverse-blocking radio eFuse; Texas_RPW0010A_VQFN-HR-10_2x2mm; MPN TPS259470ARPW
U2301: TLV803EA43 4.3V radio rail supervisor; SOT-23-3; MPN TLV803EA43RDBZR
U2302: SN74LVC1G17DBVR radio PG level restore; SOT-23-5; MPN SN74LVC1G17DBVR
U2303: TS3USB30E default-disconnected radio codec USB sw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; TSSOP-10_3x3mm_P0.5mm; MPN TS3USB30EDGSR
U2304: TPS2553D radio codec VBUS gate 0.20A; SOT-23-6; MPN TPS2553DBVR
U2305: USBLC6-2P6 radio codec USB ESD; SOT-666; MPN USBLC6-2P6

Connections:
/GNSS_EXTINT: R2326.1, R2356.1; also elsewhere on the board
/GNSS_PPS: R2325.1, R2355.1; also elsewhere on the board
/GNSS_RESET_N: R2319.1, R2354.1; also elsewhere on the board
/GNSS_UART_RX: R2318.1, R2352.1; also elsewhere on the board
/GNSS_UART_TX: R2324.1, R2353.1; also elsewhere on the board
/MCU_3V3: C2305.1, C2306.1, R2305.1, R2306.1, R2307.1, R2310.2, R2311.2, R2316.2, R2317.2, R2318.2, R2319.2, U2302.5 (VCC), U2303.10 (VCC); also elsewhere on the board
/Optional Radio Daughterboard Interface/GNSS_EXTINT_DB: J2300.29, R2356.2
/Optional Radio Daughterboard Interface/GNSS_PPS_DB: J2300.28, R2355.2
/Optional Radio Daughterboard Interface/GNSS_RESET_N_DB: J2300.27, R2354.2
/Optional Radio Daughterboard Interface/GNSS_UART_RX_DB: J2300.24, R2352.2
/Optional Radio Daughterboard Interface/GNSS_UART_TX_DB: J2300.25, R2353.2
/Optional Radio Daughterboard Interface/RADIO_CODEC_ILIM: R2308.1, U2304.5 (ILIM)
/Optional Radio Daughterboard Interface/RADIO_CODEC_USB_DM_DB: J2300.9, U2303.6 (D-), U2305.3 (I/O2), U2305.4 (I/O2)
/Optional Radio Daughterboard Interface/RADIO_CODEC_USB_DP_DB: J2300.8, U2303.4 (D+), U2305.1 (I/O1), U2305.6 (I/O1)
/Optional Radio Daughterboard Interface/RADIO_CODEC_USB_VBUS_DB: C2308.1, J2300.5, U2304.6 (OUT), U2305.5 (VBUS)
/Optional Radio Daughterboard Interface/RADIO_DB_5V: C2303.1, C2304.1, J2300.2, J2300.3, J2300.6, R2302.1, U2300.6 (OUT), U2301.3 (VDD)
/Optional Radio Daughterboard Interface/RADIO_DB_DVDT: C2300.1, U2300.7 (dVdt)
/Optional Radio Daughterboard Interface/RADIO_DB_ILM: R2301.1, U2300.9 (ILM)
/Optional Radio Daughterboard Interface/RADIO_DB_PG_DIV: R2303.2, R2304.1, U2302.2
/Optional Radio Daughterboard Interface/RADIO_DB_PG_RAW: R2302.2, R2303.1, U2301.1 (RESETz)
/Optional Radio Daughterboard Interface/RADIO_UHF_PD_N_DB: J2300.18, R2347.2
/Optional Radio Daughterboard Interface/RADIO_UHF_PTT_N_DB: J2300.16, R2345.2
/Optional Radio Daughterboard Interface/RADIO_UHF_RF_SEL_3V3_DB: J2300.23, R2351.2
/Optional Radio Daughterboard Interface/RADIO_UHF_SQL_DB: J2300.21, R2349.2
/Optional Radio Daughterboard Interface/RADIO_UHF_UART_RX_DB: J2300.14, R2343.2
/Optional Radio Daughterboard Interface/RADIO_UHF_UART_TX_DB: J2300.13, R2342.2
/Optional Radio Daughterboard Interface/RADIO_USB_OE_N: Q2300.3 (D), R2307.2, U2303.9 (~OE)
/Optional Radio Daughterboard Interface/RADIO_VHF_PD_N_DB: J2300.17, R2346.2
/Optional Radio Daughterboard Interface/RADIO_VHF_PTT_N_DB: J2300.15, R2344.2
/Optional Radio Daughterboard Interface/RADIO_VHF_RF_SEL_3V3_DB: J2300.22, R2350.2
/Optional Radio Daughterboard Interface/RADIO_VHF_SQL_DB: J2300.20, R2348.2
/Optional Radio Daughterboard Interface/RADIO_VHF_UART_RX_DB: J2300.12, R2341.2
/Optional Radio Daughterboard Interface/RADIO_VHF_UART_TX_DB: J2300.11, R2340.2
/RADIO_CODEC_USB_DM_HOST: U2303.8 (D1-); also elsewhere on the board
/RADIO_CODEC_USB_DP_HOST: U2303.2 (D1+); also elsewhere on the board
/RADIO_CODEC_USB_VBUS_HOST: C2307.1, U2304.1 (IN); also elsewhere on the board
/RADIO_DB_FAULT_N: R2305.2, U2300.4 (~FLT), U2304.4 (~FAULT); also elsewhere on the board
/RADIO_DB_PG: Q2300.1 (G), U2302.4, U2304.3 (EN); also elsewhere on the board
/RADIO_DB_PRESENT_N: J2300.30, R2306.2; also elsewhere on the board
/RADIO_DB_PWR_EN: R2300.1, U2300.1 (EN/UVLO); also elsewhere on the board
/RADIO_UHF_PD_N: R2313.1, R2347.1; also elsewhere on the board
/RADIO_UHF_PTT_N: R2311.1, R2345.1; also elsewhere on the board
/RADIO_UHF_RF_SEL_3V3: R2315.1, R2351.1; also elsewhere on the board
/RADIO_UHF_SQL: R2323.1, R2349.1; also elsewhere on the board
/RADIO_UHF_UART_RX: R2321.1, R2343.1; also elsewhere on the board
/RADIO_UHF_UART_TX: R2317.1, R2342.1; also elsewhere on the board
/RADIO_VHF_PD_N: R2312.1, R2346.1; also elsewhere on the board
/RADIO_VHF_PTT_N: R2310.1, R2344.1; also elsewhere on the board
/RADIO_VHF_RF_SEL_3V3: R2314.1, R2350.1; also elsewhere on the board
/RADIO_VHF_SQL: R2322.1, R2348.1; also elsewhere on the board
/RADIO_VHF_UART_RX: R2320.1, R2341.1; also elsewhere on the board
/RADIO_VHF_UART_TX: R2316.1, R2340.1; also elsewhere on the board
/SYS_5V: C2301.1, C2302.1, U2300.5 (IN); also elsewhere on the board
GND: C2300.2, C2301.2, C2302.2, C2303.2, C2304.2, C2305.2, C2306.2, C2307.2, C2308.2, J2300.1, J2300.4, J2300.7, J2300.10, J2300.19, J2300.26, J2300.MP, Q2300.2 (S), R2300.2, R2301.2, R2304.2, R2308.2, R2312.2, R2313.2, R2314.2, R2315.2, R2320.2, R2321.2, R2322.2, R2323.2, R2324.2, R2325.2, R2326.2, U2300.2 (OVLO), U2300.8 (GND), U2301.2 (GND), U2302.3 (GND), U2303.1 (S), U2303.5 (GND), U2304.2 (GND), U2305.2 (GND); also elsewhere on the board

Notes on the sheet:
== Default-off protected daughterboard power ==
The system-audio hub keeps its own codec on port 2; optional radio codec port 1 may remain empty without blocking enumeration.
J2300 pin 30 is passively grounded on the daughterboard. High means absent; low means physically installed.
R2340-R2352 limit fault current on every GPIO/UART/control line crossing the FFC.
FH12-30S 30-pin FFC: three 5V pins, interleaved GND for return/shielding; route them as short, wide pours with stitching vias.
USB data and VBUS remain physically disconnected until RADIO_DB_PG is valid; daughterboard faults cannot back-power the mainboard.
NOTES:
== USB codec isolation: no phantom device or back-power when daughterboard is absent ==
== Fault-isolating series resistors at the removable-board boundary ==
== J2300 Hirose FH12-30S removable radio daughterboard FFC connector ==
Firmware may enable RADIO_DB_5V only after the passive PRESENT_N strap is detected.
The main laptop cold-boots and operates normally with J2300 completely unpopulated.
Firmware must require PRESENT_N low and FAULT_N high before asserting PWR_EN, then require PG high within a timeout.
== Safe defaults for every off-board control ==
== Optional radio/GNSS/audio daughterboard interface ==

Schematic: 07_radio_oled_gps.kicad_sch

Parts:
C170: 47u E-key bulk; C_1206_3216Metric; MPN GRM31CR71E106KA12L
C171: 100n radio bypass; C_0603_1608Metric; MPN GRM188R71H104KA93D
C174: 1u OLED A local; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C175: 100n OLED A local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C178: 1u OLED B local; C_0805_2012Metric; MPN GRM21BR71A105KA01L
C179: 100n OLED B local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C185: 100n OLED mux local; C_0603_1608Metric; MPN GRM188R71H104KA93D
C187: 100n E-key control-isolator local; C_0603_1608Metric; MPN GRM188R71H104KA93D
F10: 2A E-key 3V3 fuse/polyfuse; Fuse_1206_3216Metric; MPN 1206L200PR
H4: M.2 E-key 2230 M2 grounded standoff 2.5mm; SMT_Standoff_M2_H2.5_C4_Tail2.7x1.5; MPN M2XC4X2.5+C2.7X1.5
J40: Amphenol MDT420E01001 E-key Wi-Fi/Bluetooth socket; Amphenol_MDT420E01001_H4.2; MPN MDT420E01001
J41: SSD1306 OLED A 4-pin GND/VDD/SCK/SDA; SSD1306_0.96in_Module_4Pin
J45: SSD1306 OLED B 4-pin GND/VDD/SCK/SDA; SSD1306_0.96in_Module_4Pin
R170: 10k W_DISABLE1 pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R171: 10k W_DISABLE2 pull-up; R_0603_1608Metric; MPN RC0603FR-0710KL
R173: 4.7k OLED A SCL pull-up; R_0603_1608Metric; MPN RC0603FR-074K7L
R176: 0R / PERST isolation; R_0603_1608Metric; MPN RC0603FR-070RL
R177: 0R / REFCLK+ isolation; R_0603_1608Metric; MPN RC0603FR-070RL
R178: 0R / REFCLK- isolation; R_0603_1608Metric; MPN RC0603FR-070RL
R179: 4.7k OLED A SDA pull-up; R_0603_1608Metric; MPN RC0603FR-074K7L
R196: 4.7k OLED B SCL pull-up; R_0603_1608Metric; MPN RC0603FR-074K7L
R197: 4.7k OLED B SDA pull-up; R_0603_1608Metric; MPN RC0603FR-074K7L
R198: 100k WLAN disable default asserted; R_0603_1608Metric; MPN RC0603FR-07100KL
R199: 100k Bluetooth disable default asserted; R_0603_1608Metric; MPN RC0603FR-07100KL
U45: TCA9548A service I2C mux @0x70; TSSOP-24_4.4x7.8mm_P0.65mm; MPN TCA9548APWR
U170: SN74LVC3G34DCUR E-key control isolation; VSSOP-8_2.3x2mm_P0.5mm; MPN SN74LVC3G34DCUR

Connections:
/I2C_SCL: U45.22 (SCL); also elsewhere on the board
/I2C_SDA: U45.23 (SDA); also elsewhere on the board
/MCU_3V3: C174.1, C175.1, C178.1, C179.1, C185.1, J41.2, J45.2, R173.1, R179.1, R196.1, R197.1, U45.24 (VCC); also elsewhere on the board
/PCIE_3V3: F10.1; also elsewhere on the board
/PCIE_WAKE_N: J40.55 (~PEWAKE0); also elsewhere on the board
/PD1_I2C_SCL: U45.9 (SC2); also elsewhere on the board
/PD1_I2C_SDA: U45.8 (SD2); also elsewhere on the board
/PD2_I2C_SCL: U45.11 (SC3); also elsewhere on the board
/PD2_I2C_SDA: U45.10 (SD3); also elsewhere on the board
/PLTRST_SRC_N: R176.1; also elsewhere on the board
/SERVICE_MUX_RESET_N: U45.3 (~RESET); also elsewhere on the board
/WIFI_CLKREQ_N: J40.53 (~CLKREQ0); also elsewhere on the board
/WIFI_PCIE_RX_N: J40.43 (PERn0); also elsewhere on the board
/WIFI_PCIE_RX_P: J40.41 (PERp0); also elsewhere on the board
/WIFI_PCIE_TX_N: J40.37 (PETn0); also elsewhere on the board
/WIFI_PCIE_TX_P: J40.35 (PETp0); also elsewhere on the board
/WIFI_REFCLK_N: R178.1; also elsewhere on the board
/WIFI_REFCLK_P: R177.1; also elsewhere on the board
/WIFI_USB_DN: J40.5 (USB_D-); also elsewhere on the board
/WIFI_USB_DP: J40.3 (USB_D+); also elsewhere on the board
/WIFI_W_DISABLE1_N_EC: R198.1, U170.1; also elsewhere on the board
/WIFI_W_DISABLE2_N_EC: R199.1, U170.6; also elsewhere on the board
/Wi-Fi/Bluetooth & OLEDs/OLED_A_SCL: J41.3, R173.2, U45.5 (SC0)
/Wi-Fi/Bluetooth & OLEDs/OLED_A_SDA: J41.4, R179.2, U45.4 (SD0)
/Wi-Fi/Bluetooth & OLEDs/OLED_B_SCL: J45.3, R196.2, U45.7 (SC1)
/Wi-Fi/Bluetooth & OLEDs/OLED_B_SDA: J45.4, R197.2, U45.6 (SD1)
/Wi-Fi/Bluetooth & OLEDs/WIFI_3V3: C170.1, C171.1, C187.1, F10.2, J40.2 (3.3V), J40.4 (3.3V), J40.72 (3.3V), J40.74 (3.3V), R170.1, R171.1, U170.8 (VCC)
/Wi-Fi/Bluetooth & OLEDs/WIFI_PERST_N: J40.52 (~PERST0), R176.2
/Wi-Fi/Bluetooth & OLEDs/WIFI_REFCLK_E_N: J40.49 (REFCLKn0), R178.2
/Wi-Fi/Bluetooth & OLEDs/WIFI_REFCLK_E_P: J40.47 (REFCLKp0), R177.2
/Wi-Fi/Bluetooth & OLEDs/WIFI_W_DISABLE1_N: J40.56 (~W_DISABLE1), R170.2, U170.7
/Wi-Fi/Bluetooth & OLEDs/WIFI_W_DISABLE2_N: J40.54 (~W_DISABLE2), R171.2, U170.2
GND: C170.2, C171.2, C174.2, C175.2, C178.2, C179.2, C185.2, C187.2, H4.1 (1_1), J40.1 (GND), J40.7 (GND), J40.18 (GND), J40.33 (GND), J40.39 (GND), J40.45 (GND), J40.51 (GND), J40.57 (GND), J40.63 (GND), J40.69 (GND), J40.75 (GND), J41.1, J45.1, R198.2, R199.2, U45.1 (A0), U45.2 (A1), U45.12 (GND), U45.21 (A2), U170.3, U170.4 (GND); also elsewhere on the board

Notes on the sheet:
SUSCLK, SDIO, PCM/I2S, UIM, and vendor-defined E-key pins remain NC for the AX210-class module target.
M.2 E-key remains on the mainboard; GNSS and amateur-radio hardware moved to the optional radio daughterboard.
== Dual SSD1306 I2C OLED/status display headers ==
Channels 4-7 remain unused and explicitly no-connected for future service expansion.
NOTES:
The optional-board interface provides independent safe defaults for every radio/GNSS signal.
USB2_P1 carries Bluetooth; default-BIOS HSIO3/REFCLK3/CLKREQ3 carry the E-key PCIe function.
OLED headers match common 4-pin SSD1306 modules: GND, VDD/3V3, SCK/SCL, SDA. Use 3.3V modules only.
M.2 E-key directions are host TX->PET35/37 and PER41/43->host RX; Mu-side TX has 220n AC coupling.
== Wi-Fi/Bluetooth and dual OLED peripherals ==
Qualified radio is Intel AX210.NGWGIE.NV M.2 2230 Key-E: Wi-Fi over PCIe and Bluetooth over USB; AX211/CNVio2 is prohibited.
== J40 M.2 E-key Wi-Fi/Bluetooth module ==
TCA9548A channels 0/1 isolate the identical 0x3C OLEDs; channels 2/3 isolate the two TPS25751A service buses.
U170 isolates powered-off E-key controls; R198/R199 keep WLAN and Bluetooth disabled until EC firmware explicitly enables them.
Both SSD1306 displays remain on the always-on EC service bus and work without the radio daughterboard.
The mainboard OLED and Wi-Fi functions do not depend on radio-daughterboard presence or power.
GNSS, amateur-radio modules, RF switching, and the dedicated radio codec are isolated on the removable daughterboard.
Hardware-gated SERVICE_MUX_RESET_N asserts during every EC reset; firmware selects one TPS25751A channel and validates PD Status 0x35 plus PDO/RDO 0x31/0x32.
